v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -1760 -1105 -1690 -1105 {lab=vdd}
N -1760 -1085 -1690 -1085 {lab=vss}
N 130 -740 130 -720 {lab=vdd}
N 130 90 130 110 {lab=vss}
N -40 -670 -20 -670 {lab=x0_c0_f_not}
N -40 -690 -20 -690 {lab=x0_c0_f}
N -1760 -1045 -1690 -1045 {lab=a0}
N -1760 -1025 -1690 -1025 {lab=a0_not}
N -1760 -1005 -1690 -1005 {lab=a1}
N -1760 -985 -1690 -985 {lab=a1_not}
N -1760 -965 -1690 -965 {lab=a2}
N -1760 -945 -1690 -945 {lab=a2_not}
N -1760 -925 -1690 -925 {lab=a3}
N -1760 -905 -1690 -905 {lab=a3_not}
N -1760 -885 -1690 -885 {lab=a4}
N -1760 -865 -1690 -865 {lab=a4_not}
N -1760 -845 -1690 -845 {lab=a5}
N -1760 -825 -1690 -825 {lab=a5_not}
N -1760 -805 -1690 -805 {lab=a6}
N -1760 -785 -1690 -785 {lab=a6_not}
N -1760 -765 -1690 -765 {lab=a7}
N -1760 -745 -1690 -745 {lab=a7_not}
N -1760 -705 -1690 -705 {lab=b0}
N -1760 -685 -1690 -685 {lab=b0_not}
N -1760 -665 -1690 -665 {lab=b1}
N -1760 -645 -1690 -645 {lab=b1_not}
N 130 -1130 130 -1120 {lab=vdd}
N 130 -800 130 -790 {lab=vss}
N -30 -930 -20 -930 {lab=b0_c0}
N -30 -1010 -20 -1010 {lab=a0}
N -30 -990 -20 -990 {lab=a0_not}
N -30 -970 -20 -970 {lab=b0}
N -30 -950 -20 -950 {lab=b0_not}
N -1180 -1132.5 -1180 -1122.5 {lab=vdd}
N -1340 -932.5 -1330 -932.5 {lab=b1_c0}
N -1340 -912.5 -1330 -912.5 {lab=b1_c0_not}
N -1340 -1012.5 -1330 -1012.5 {lab=a0}
N -1340 -992.5 -1330 -992.5 {lab=a0_not}
N -1340 -972.5 -1330 -972.5 {lab=b1}
N -1340 -952.5 -1330 -952.5 {lab=b1_not}
N -1030 -932.5 -1020 -932.5 {lab=b1_r0}
N -1030 -912.5 -1020 -912.5 {lab=b1_r0_not}
N -1190 -802.5 -1180 -802.5 {lab=vss}
N -1180 -767.5 -1180 -757.5 {lab=vdd}
N -1340 -567.5 -1330 -567.5 {lab=b1_c1}
N -1340 -547.5 -1330 -547.5 {lab=b1_c1_not}
N -1340 -647.5 -1330 -647.5 {lab=a1}
N -1340 -627.5 -1330 -627.5 {lab=a1_not}
N -1340 -607.5 -1330 -607.5 {lab=b1}
N -1340 -587.5 -1330 -587.5 {lab=b1_not}
N -1030 -567.5 -1020 -567.5 {lab=b1_r1}
N -1030 -547.5 -1020 -547.5 {lab=b1_r1_not}
N -1190 -437.5 -1180 -437.5 {lab=vss}
N -1180 -402.5 -1180 -392.5 {lab=vdd}
N -1340 -202.5 -1330 -202.5 {lab=b1_c2}
N -1340 -182.5 -1330 -182.5 {lab=b1_c2_not}
N -1340 -282.5 -1330 -282.5 {lab=a2}
N -1340 -262.5 -1330 -262.5 {lab=a2_not}
N -1340 -242.5 -1330 -242.5 {lab=b1}
N -1340 -222.5 -1330 -222.5 {lab=b1_not}
N -1030 -202.5 -1020 -202.5 {lab=b1_r2}
N -1030 -182.5 -1020 -182.5 {lab=b1_r2_not}
N -1190 -72.5 -1180 -72.5 {lab=vss}
N -1180 -37.5 -1180 -27.5 {lab=vdd}
N -1340 162.5 -1330 162.5 {lab=b1_c3}
N -1340 182.5 -1330 182.5 {lab=b1_c3_not}
N -1340 82.5 -1330 82.5 {lab=a3}
N -1340 102.5 -1330 102.5 {lab=a3_not}
N -1340 122.5 -1330 122.5 {lab=b1}
N -1340 142.5 -1330 142.5 {lab=b1_not}
N -1030 162.5 -1020 162.5 {lab=b1_r3}
N -1030 182.5 -1020 182.5 {lab=b1_r3_not}
N -1190 292.5 -1180 292.5 {lab=vss}
N -1180 340 -1180 350 {lab=vdd}
N -1340 540 -1330 540 {lab=b1_c4}
N -1340 560 -1330 560 {lab=b1_c4_not}
N -1340 460 -1330 460 {lab=a4}
N -1340 480 -1330 480 {lab=a4_not}
N -1340 500 -1330 500 {lab=b1}
N -1340 520 -1330 520 {lab=b1_not}
N -1030 540 -1020 540 {lab=b1_r4}
N -1030 560 -1020 560 {lab=b1_r4_not}
N -1190 670 -1180 670 {lab=vss}
N -1180 705 -1180 715 {lab=vdd}
N -1340 905 -1330 905 {lab=b1_c5}
N -1340 925 -1330 925 {lab=b1_c5_not}
N -1340 825 -1330 825 {lab=a5}
N -1340 845 -1330 845 {lab=a5_not}
N -1340 865 -1330 865 {lab=b1}
N -1340 885 -1330 885 {lab=b1_not}
N -1030 905 -1020 905 {lab=b1_r5}
N -1030 925 -1020 925 {lab=b1_r5_not}
N -1190 1035 -1180 1035 {lab=vss}
N -1180 1070 -1180 1080 {lab=vdd}
N -1340 1270 -1330 1270 {lab=b1_c6}
N -1340 1290 -1330 1290 {lab=b1_c6_not}
N -1340 1190 -1330 1190 {lab=a6}
N -1340 1210 -1330 1210 {lab=a6_not}
N -1340 1230 -1330 1230 {lab=b1}
N -1340 1250 -1330 1250 {lab=b1_not}
N -1030 1270 -1020 1270 {lab=b1_r6}
N -1030 1290 -1020 1290 {lab=b1_r6_not}
N -1190 1400 -1180 1400 {lab=vss}
N -1180 1435 -1180 1445 {lab=vdd}
N -1340 1635 -1330 1635 {lab=b1_c7}
N -1340 1655 -1330 1655 {lab=b1_c7_not}
N -1340 1555 -1330 1555 {lab=a7}
N -1340 1575 -1330 1575 {lab=a7_not}
N -1340 1595 -1330 1595 {lab=b1}
N -1340 1615 -1330 1615 {lab=b1_not}
N -1030 1635 -1020 1635 {lab=b1_r7}
N -1030 1655 -1020 1655 {lab=b1_r7_not}
N -1190 1765 -1180 1765 {lab=vss}
N -882.5 -935 -872.5 -935 {lab=b0_c1}
N -882.5 -915 -872.5 -915 {lab=b0_c1_not}
N -882.5 -1015 -872.5 -1015 {lab=a1}
N -882.5 -995 -872.5 -995 {lab=a1_not}
N -882.5 -975 -872.5 -975 {lab=b0}
N -882.5 -955 -872.5 -955 {lab=b0_not}
N -572.5 -935 -562.5 -935 {lab=b0_r1}
N -572.5 -915 -562.5 -915 {lab=b0_r1_not}
N -732.5 -805 -722.5 -805 {lab=vss}
N -722.5 -770 -722.5 -760 {lab=vdd}
N -882.5 -570 -872.5 -570 {lab=b0_c2}
N -882.5 -550 -872.5 -550 {lab=b0_c2_not}
N -882.5 -650 -872.5 -650 {lab=a2}
N -882.5 -630 -872.5 -630 {lab=a2_not}
N -882.5 -610 -872.5 -610 {lab=b0}
N -882.5 -590 -872.5 -590 {lab=b0_not}
N -572.5 -570 -562.5 -570 {lab=b0_r2}
N -572.5 -550 -562.5 -550 {lab=b0_r2_not}
N -732.5 -440 -722.5 -440 {lab=vss}
N -722.5 -405 -722.5 -395 {lab=vdd}
N -882.5 -205 -872.5 -205 {lab=b0_c3}
N -882.5 -185 -872.5 -185 {lab=b0_c3_not}
N -882.5 -285 -872.5 -285 {lab=a3}
N -882.5 -265 -872.5 -265 {lab=a3_not}
N -882.5 -245 -872.5 -245 {lab=b0}
N -882.5 -225 -872.5 -225 {lab=b0_not}
N -572.5 -205 -562.5 -205 {lab=b0_r3}
N -572.5 -185 -562.5 -185 {lab=b0_r3_not}
N -732.5 -75 -722.5 -75 {lab=vss}
N -722.5 -27.5 -722.5 -17.5 {lab=vdd}
N -882.5 172.5 -872.5 172.5 {lab=b0_c4}
N -882.5 192.5 -872.5 192.5 {lab=b0_c4_not}
N -882.5 92.5 -872.5 92.5 {lab=a4}
N -882.5 112.5 -872.5 112.5 {lab=a4_not}
N -882.5 132.5 -872.5 132.5 {lab=b0}
N -882.5 152.5 -872.5 152.5 {lab=b0_not}
N -572.5 172.5 -562.5 172.5 {lab=b0_r4}
N -572.5 192.5 -562.5 192.5 {lab=b0_r4_not}
N -732.5 302.5 -722.5 302.5 {lab=vss}
N -722.5 337.5 -722.5 347.5 {lab=vdd}
N -882.5 537.5 -872.5 537.5 {lab=b0_c5}
N -882.5 557.5 -872.5 557.5 {lab=b0_c5_not}
N -882.5 457.5 -872.5 457.5 {lab=a5}
N -882.5 477.5 -872.5 477.5 {lab=a5_not}
N -882.5 497.5 -872.5 497.5 {lab=b0}
N -882.5 517.5 -872.5 517.5 {lab=b0_not}
N -572.5 537.5 -562.5 537.5 {lab=b0_r5}
N -572.5 557.5 -562.5 557.5 {lab=b0_r5_not}
N -732.5 667.5 -722.5 667.5 {lab=vss}
N -722.5 702.5 -722.5 712.5 {lab=vdd}
N -882.5 902.5 -872.5 902.5 {lab=b0_c6}
N -882.5 922.5 -872.5 922.5 {lab=b0_c6_not}
N -882.5 822.5 -872.5 822.5 {lab=a6}
N -882.5 842.5 -872.5 842.5 {lab=a6_not}
N -882.5 862.5 -872.5 862.5 {lab=b0}
N -882.5 882.5 -872.5 882.5 {lab=b0_not}
N -572.5 902.5 -562.5 902.5 {lab=b0_r6}
N -572.5 922.5 -562.5 922.5 {lab=b0_r6_not}
N -732.5 1032.5 -722.5 1032.5 {lab=vss}
N -722.5 1067.5 -722.5 1077.5 {lab=vdd}
N -882.5 1267.5 -872.5 1267.5 {lab=b0_c7}
N -882.5 1287.5 -872.5 1287.5 {lab=b0_c7_not}
N -882.5 1187.5 -872.5 1187.5 {lab=a7}
N -882.5 1207.5 -872.5 1207.5 {lab=a7_not}
N -882.5 1227.5 -872.5 1227.5 {lab=b0}
N -882.5 1247.5 -872.5 1247.5 {lab=b0_not}
N -572.5 1267.5 -562.5 1267.5 {lab=b0_r7}
N -572.5 1287.5 -562.5 1287.5 {lab=b0_r7_not}
N -732.5 1397.5 -722.5 1397.5 {lab=vss}
N -722.5 -1135 -722.5 -1125 {lab=vdd}
N -42.5 -610 -20 -610 {lab=b0_r1}
N -42.5 -590 -20 -590 {lab=b0_r1_not}
N -42.5 -650 -20 -650 {lab=b1_r0}
N -42.5 -630 -20 -630 {lab=b1_r0_not}
N -42.5 -530 -20 -530 {lab=b0_r2}
N -42.5 -510 -20 -510 {lab=b0_r2_not}
N -42.5 -570 -20 -570 {lab=b1_r1}
N -42.5 -550 -20 -550 {lab=b1_r1_not}
N -42.5 -450 -20 -450 {lab=b0_r3}
N -42.5 -430 -20 -430 {lab=b0_r3_not}
N -42.5 -490 -20 -490 {lab=b1_r2}
N -42.5 -470 -20 -470 {lab=b1_r2_not}
N -42.5 -370 -20 -370 {lab=b0_r4}
N -42.5 -350 -20 -350 {lab=b0_r4_not}
N -42.5 -410 -20 -410 {lab=b1_r3}
N -42.5 -390 -20 -390 {lab=b1_r3_not}
N -42.5 -290 -20 -290 {lab=b0_r5}
N -42.5 -270 -20 -270 {lab=b0_r5_not}
N -42.5 -330 -20 -330 {lab=b1_r4}
N -42.5 -310 -20 -310 {lab=b1_r4_not}
N -42.5 -210 -20 -210 {lab=b0_r6}
N -42.5 -190 -20 -190 {lab=b0_r6_not}
N -42.5 -250 -20 -250 {lab=b1_r5}
N -42.5 -230 -20 -230 {lab=b1_r5_not}
N -42.5 -130 -20 -130 {lab=b0_r7}
N -42.5 -110 -20 -110 {lab=b0_r7_not}
N -42.5 -170 -20 -170 {lab=b1_r6}
N -42.5 -150 -20 -150 {lab=b1_r6_not}
N -30 -910 -20 -910 {lab=b0_c0_not}
N -42.5 -90 -20 -90 {lab=b1_r7}
N -42.5 -70 -20 -70 {lab=b1_r7_not}
N -42.5 -50 -20 -50 {lab=x0_a7_f}
N -42.5 -30 -20 -30 {lab=x0_a7_f_not}
N 280 -930 290 -930 {lab=p0}
N 280 -910 290 -910 {lab=p0_not}
N 280 -650 290 -650 {lab=p1}
N 280 -630 290 -630 {lab=p1_not}
N 1367.5 -732.5 1367.5 -722.5 {lab=vdd}
N 1207.5 -532.5 1217.5 -532.5 {lab=b2_c0}
N 1207.5 -512.5 1217.5 -512.5 {lab=b2_c0_not}
N 1207.5 -612.5 1217.5 -612.5 {lab=a0}
N 1207.5 -592.5 1217.5 -592.5 {lab=a0_not}
N 1207.5 -572.5 1217.5 -572.5 {lab=b2}
N 1207.5 -552.5 1217.5 -552.5 {lab=b2_not}
N 1517.5 -532.5 1527.5 -532.5 {lab=b2_r0}
N 1517.5 -512.5 1527.5 -512.5 {lab=b2_r0_not}
N 1357.5 -402.5 1367.5 -402.5 {lab=vss}
N 1367.5 -367.5 1367.5 -357.5 {lab=vdd}
N 1207.5 -167.5 1217.5 -167.5 {lab=b2_c1}
N 1207.5 -147.5 1217.5 -147.5 {lab=b2_c1_not}
N 1207.5 -247.5 1217.5 -247.5 {lab=a1}
N 1207.5 -227.5 1217.5 -227.5 {lab=a1_not}
N 1207.5 -207.5 1217.5 -207.5 {lab=b2}
N 1207.5 -187.5 1217.5 -187.5 {lab=b2_not}
N 1517.5 -167.5 1527.5 -167.5 {lab=b2_r1}
N 1517.5 -147.5 1527.5 -147.5 {lab=b2_r1_not}
N 1357.5 -37.5 1367.5 -37.5 {lab=vss}
N 1367.5 -2.5 1367.5 7.5 {lab=vdd}
N 1207.5 197.5 1217.5 197.5 {lab=b2_c2}
N 1207.5 217.5 1217.5 217.5 {lab=b2_c2_not}
N 1207.5 117.5 1217.5 117.5 {lab=a2}
N 1207.5 137.5 1217.5 137.5 {lab=a2_not}
N 1207.5 157.5 1217.5 157.5 {lab=b2}
N 1207.5 177.5 1217.5 177.5 {lab=b2_not}
N 1517.5 197.5 1527.5 197.5 {lab=b2_r2}
N 1517.5 217.5 1527.5 217.5 {lab=b2_r2_not}
N 1357.5 327.5 1367.5 327.5 {lab=vss}
N 1367.5 362.5 1367.5 372.5 {lab=vdd}
N 1207.5 562.5 1217.5 562.5 {lab=b2_c3}
N 1207.5 582.5 1217.5 582.5 {lab=b2_c3_not}
N 1207.5 482.5 1217.5 482.5 {lab=a3}
N 1207.5 502.5 1217.5 502.5 {lab=a3_not}
N 1207.5 522.5 1217.5 522.5 {lab=b2}
N 1207.5 542.5 1217.5 542.5 {lab=b2_not}
N 1517.5 562.5 1527.5 562.5 {lab=b2_r3}
N 1517.5 582.5 1527.5 582.5 {lab=b2_r3_not}
N 1357.5 692.5 1367.5 692.5 {lab=vss}
N 1367.5 740 1367.5 750 {lab=vdd}
N 1207.5 940 1217.5 940 {lab=b2_c4}
N 1207.5 960 1217.5 960 {lab=b2_c4_not}
N 1207.5 860 1217.5 860 {lab=a4}
N 1207.5 880 1217.5 880 {lab=a4_not}
N 1207.5 900 1217.5 900 {lab=b2}
N 1207.5 920 1217.5 920 {lab=b2_not}
N 1517.5 940 1527.5 940 {lab=b2_r4}
N 1517.5 960 1527.5 960 {lab=b2_r4_not}
N 1357.5 1070 1367.5 1070 {lab=vss}
N 1367.5 1105 1367.5 1115 {lab=vdd}
N 1207.5 1305 1217.5 1305 {lab=b2_c5}
N 1207.5 1325 1217.5 1325 {lab=b2_c5_not}
N 1207.5 1225 1217.5 1225 {lab=a5}
N 1207.5 1245 1217.5 1245 {lab=a5_not}
N 1207.5 1265 1217.5 1265 {lab=b2}
N 1207.5 1285 1217.5 1285 {lab=b2_not}
N 1517.5 1305 1527.5 1305 {lab=b2_r5}
N 1517.5 1325 1527.5 1325 {lab=b2_r5_not}
N 1357.5 1435 1367.5 1435 {lab=vss}
N 1367.5 1470 1367.5 1480 {lab=vdd}
N 1207.5 1670 1217.5 1670 {lab=b2_c6}
N 1207.5 1690 1217.5 1690 {lab=b2_c6_not}
N 1207.5 1590 1217.5 1590 {lab=a6}
N 1207.5 1610 1217.5 1610 {lab=a6_not}
N 1207.5 1630 1217.5 1630 {lab=b2}
N 1207.5 1650 1217.5 1650 {lab=b2_not}
N 1517.5 1670 1527.5 1670 {lab=b2_r6}
N 1517.5 1690 1527.5 1690 {lab=b2_r6_not}
N 1357.5 1800 1367.5 1800 {lab=vss}
N 1367.5 1835 1367.5 1845 {lab=vdd}
N 1207.5 2035 1217.5 2035 {lab=b2_c7}
N 1207.5 2055 1217.5 2055 {lab=b2_c7_not}
N 1207.5 1955 1217.5 1955 {lab=a7}
N 1207.5 1975 1217.5 1975 {lab=a7_not}
N 1207.5 1995 1217.5 1995 {lab=b2}
N 1207.5 2015 1217.5 2015 {lab=b2_not}
N 1517.5 2035 1527.5 2035 {lab=b2_r7}
N 1517.5 2055 1527.5 2055 {lab=b2_r7_not}
N 1357.5 2165 1367.5 2165 {lab=vss}
N 280 -610 290 -610 {lab=b0_r1_b}
N 280 -590 290 -590 {lab=b0_r1_b_not}
N 280 -530 290 -530 {lab=b0_r2_b}
N 280 -510 290 -510 {lab=b0_r2_b_not}
N 280 -970 290 -970 {lab=b0_q0}
N 280 -950 290 -950 {lab=b0_q0_not}
N 280 -1010 290 -1010 {lab=b0_p0}
N 280 -990 290 -990 {lab=b0_p0_not}
N -572.5 -975 -562.5 -975 {lab=b0_q1}
N -572.5 -955 -562.5 -955 {lab=b0_q1_not}
N -572.5 -1015 -562.5 -1015 {lab=b0_p1}
N -572.5 -995 -562.5 -995 {lab=b0_p1_not}
N -572.5 -610 -562.5 -610 {lab=b0_q2}
N -572.5 -590 -562.5 -590 {lab=b0_q2_not}
N -572.5 -650 -562.5 -650 {lab=b0_p2}
N -572.5 -630 -562.5 -630 {lab=b0_p2_not}
N -572.5 -245 -562.5 -245 {lab=b0_q3}
N -572.5 -225 -562.5 -225 {lab=b0_q3_not}
N -572.5 -285 -562.5 -285 {lab=b0_p3}
N -572.5 -265 -562.5 -265 {lab=b0_p3_not}
N -572.5 132.5 -562.5 132.5 {lab=b0_q4}
N -572.5 152.5 -562.5 152.5 {lab=b0_q4_not}
N -572.5 92.5 -562.5 92.5 {lab=b0_p4}
N -572.5 112.5 -562.5 112.5 {lab=b0_p4_not}
N -572.5 497.5 -562.5 497.5 {lab=b0_q5}
N -572.5 517.5 -562.5 517.5 {lab=b0_q5_not}
N -572.5 457.5 -562.5 457.5 {lab=b0_p5}
N -572.5 477.5 -562.5 477.5 {lab=b0_p5_not}
N -572.5 862.5 -562.5 862.5 {lab=b0_q6}
N -572.5 882.5 -562.5 882.5 {lab=b0_q6_not}
N -572.5 822.5 -562.5 822.5 {lab=b0_p6}
N -572.5 842.5 -562.5 842.5 {lab=b0_p6_not}
N -572.5 1227.5 -562.5 1227.5 {lab=b0_q7}
N -572.5 1247.5 -562.5 1247.5 {lab=b0_q7_not}
N -572.5 1187.5 -562.5 1187.5 {lab=b0_p7}
N -572.5 1207.5 -562.5 1207.5 {lab=b0_p7_not}
N -1030 1595 -1020 1595 {lab=b1_q7}
N -1030 1615 -1020 1615 {lab=b1_q7_not}
N -1030 1555 -1020 1555 {lab=b1_p7}
N -1030 1575 -1020 1575 {lab=b1_p7_not}
N -1030 1230 -1020 1230 {lab=b1_q6}
N -1030 1250 -1020 1250 {lab=b1_q6_not}
N -1030 1190 -1020 1190 {lab=b1_p6}
N -1030 1210 -1020 1210 {lab=b1_p6_not}
N -1030 865 -1020 865 {lab=b1_q5}
N -1030 885 -1020 885 {lab=b1_q5_not}
N -1030 825 -1020 825 {lab=b1_p5}
N -1030 845 -1020 845 {lab=b1_p5_not}
N -1030 500 -1020 500 {lab=b1_q4}
N -1030 520 -1020 520 {lab=b1_q4_not}
N -1030 460 -1020 460 {lab=b1_p4}
N -1030 480 -1020 480 {lab=b1_p4_not}
N -1030 122.5 -1020 122.5 {lab=b1_q3}
N -1030 142.5 -1020 142.5 {lab=b1_q3_not}
N -1030 82.5 -1020 82.5 {lab=b1_p3}
N -1030 102.5 -1020 102.5 {lab=b1_p3_not}
N -1030 -242.5 -1020 -242.5 {lab=b1_q2}
N -1030 -222.5 -1020 -222.5 {lab=b1_q2_not}
N -1030 -282.5 -1020 -282.5 {lab=b1_p2}
N -1030 -262.5 -1020 -262.5 {lab=b1_p2_not}
N -1030 -607.5 -1020 -607.5 {lab=b1_q1}
N -1030 -587.5 -1020 -587.5 {lab=b1_q1_not}
N -1030 -647.5 -1020 -647.5 {lab=b1_p1}
N -1030 -627.5 -1020 -627.5 {lab=b1_p1_not}
N -1030 -972.5 -1020 -972.5 {lab=b1_q0}
N -1030 -952.5 -1020 -952.5 {lab=b1_q0_not}
N -1030 -1012.5 -1020 -1012.5 {lab=b1_p0}
N -1030 -992.5 -1020 -992.5 {lab=b1_p0_not}
N 1517.5 -572.5 1527.5 -572.5 {lab=b2_q0}
N 1517.5 -552.5 1527.5 -552.5 {lab=b2_q0_not}
N 1517.5 -612.5 1527.5 -612.5 {lab=b2_p0}
N 1517.5 -592.5 1527.5 -592.5 {lab=b2_p0_not}
N 1517.5 -207.5 1527.5 -207.5 {lab=b2_q1}
N 1517.5 -187.5 1527.5 -187.5 {lab=b2_q1_not}
N 1517.5 -247.5 1527.5 -247.5 {lab=b2_p1}
N 1517.5 -227.5 1527.5 -227.5 {lab=b2_p1_not}
N 1517.5 157.5 1527.5 157.5 {lab=b2_q2}
N 1517.5 177.5 1527.5 177.5 {lab=b2_q2_not}
N 1517.5 117.5 1527.5 117.5 {lab=b2_p2}
N 1517.5 137.5 1527.5 137.5 {lab=b2_p2_not}
N 1517.5 522.5 1527.5 522.5 {lab=b2_q3}
N 1517.5 542.5 1527.5 542.5 {lab=b2_q3_not}
N 1517.5 482.5 1527.5 482.5 {lab=b2_p3}
N 1517.5 502.5 1527.5 502.5 {lab=b2_p3_not}
N 1517.5 900 1527.5 900 {lab=b2_q4}
N 1517.5 920 1527.5 920 {lab=b2_q4_not}
N 1517.5 860 1527.5 860 {lab=b2_p4}
N 1517.5 880 1527.5 880 {lab=b2_p4_not}
N 1517.5 1265 1527.5 1265 {lab=b2_q5}
N 1517.5 1285 1527.5 1285 {lab=b2_q5_not}
N 1517.5 1225 1527.5 1225 {lab=b2_p5}
N 1517.5 1245 1527.5 1245 {lab=b2_p5_not}
N 1517.5 1630 1527.5 1630 {lab=b2_q6}
N 1517.5 1650 1527.5 1650 {lab=b2_q6_not}
N 1517.5 1590 1527.5 1590 {lab=b2_p6}
N 1517.5 1610 1527.5 1610 {lab=b2_p6_not}
N 1517.5 1995 1527.5 1995 {lab=b2_q7}
N 1517.5 2015 1527.5 2015 {lab=b2_q7_not}
N 1517.5 1955 1527.5 1955 {lab=b2_p7}
N 1517.5 1975 1527.5 1975 {lab=b2_p7_not}
N 2070 -720 2070 -700 {lab=vdd}
N 2070 110 2070 130 {lab=vss}
N 280 -570 290 -570 {lab=x0_s1}
N 280 -550 290 -550 {lab=x0_s1_not}
N 1910 -590 1920 -590 {lab=b2_r0}
N 1910 -570 1920 -570 {lab=b2_r0_not}
N 1910 -630 1920 -630 {lab=x0_s1}
N 1910 -610 1920 -610 {lab=x0_s1_not}
N 1900 -650 1920 -650 {lab=x1_c0_f_not}
N 1900 -670 1920 -670 {lab=x1_c0_f}
N 1910 -510 1920 -510 {lab=b2_r1}
N 1910 -490 1920 -490 {lab=b2_r1_not}
N 1910 -550 1920 -550 {lab=x0_s2}
N 1910 -530 1920 -530 {lab=x0_s2_not}
N 280 -490 290 -490 {lab=x0_s2}
N 280 -470 290 -470 {lab=x0_s2_not}
N 1910 -430 1920 -430 {lab=b2_r2}
N 1910 -410 1920 -410 {lab=b2_r2_not}
N 1910 -470 1920 -470 {lab=x0_s3}
N 1910 -450 1920 -450 {lab=x0_s3_not}
N 1910 -350 1920 -350 {lab=b2_r3}
N 1910 -330 1920 -330 {lab=b2_r3_not}
N 1910 -390 1920 -390 {lab=x0_s4}
N 1910 -370 1920 -370 {lab=x0_s4_not}
N 1910 -270 1920 -270 {lab=b2_r4}
N 1910 -250 1920 -250 {lab=b2_r4_not}
N 1910 -310 1920 -310 {lab=x0_s5}
N 1910 -290 1920 -290 {lab=x0_s5_not}
N 1910 -190 1920 -190 {lab=b2_r5}
N 1910 -170 1920 -170 {lab=b2_r5_not}
N 1910 -230 1920 -230 {lab=x0_s6}
N 1910 -210 1920 -210 {lab=x0_s6_not}
N 1910 -110 1920 -110 {lab=b2_r6}
N 1910 -90 1920 -90 {lab=b2_r6_not}
N 1910 -150 1920 -150 {lab=x0_s7}
N 1910 -130 1920 -130 {lab=x0_s7_not}
N 1910 -30 1920 -30 {lab=b2_r7}
N 1910 -10 1920 -10 {lab=b2_r7_not}
N 1910 -70 1920 -70 {lab=x0_s8}
N 1910 -50 1920 -50 {lab=x0_s8_not}
N 582.5 60 692.5 60 {lab=x0_b0_f_not}
N 442.5 120 692.5 120 {lab=x0_s8}
N 442.5 90 492.5 90 {lab=vss}
N 642.5 90 692.5 90 {lab=vdd}
N 442.5 180 692.5 180 {lab=x0_s8}
N 442.5 240 692.5 240 {lab=x0_b0_f}
N 442.5 210 492.5 210 {lab=vss}
N 642.5 210 692.5 210 {lab=vdd}
N 442.5 130 442.5 180 {lab=x0_s8}
N 402.5 90 402.5 150 {lab=#net1}
N 562.5 150 732.5 150 {lab=#net1}
N 732.5 150 732.5 210 {lab=#net1}
N 442.5 300 692.5 300 {lab=x0_b0_f}
N 442.5 360 692.5 360 {lab=x0_s8_not}
N 442.5 330 492.5 330 {lab=vss}
N 642.5 330 692.5 330 {lab=vdd}
N 442.5 420 692.5 420 {lab=x0_s8_not}
N 582.5 480 692.5 480 {lab=x0_b0_f_not}
N 442.5 450 492.5 450 {lab=vss}
N 642.5 450 692.5 450 {lab=vdd}
N 442.5 370 442.5 420 {lab=x0_s8_not}
N 402.5 330 402.5 390 {lab=#net1}
N 562.5 390 732.5 390 {lab=#net1}
N 732.5 390 732.5 450 {lab=#net1}
N 442.5 270 442.5 300 {lab=x0_b0_f}
N 382.5 210 402.5 210 {lab=#net2}
N 352.5 510 582.5 510 {lab=x0_b0_f_not}
N 562.5 0 562.5 150 {lab=#net1}
N 562.5 150 562.5 390 {lab=#net1}
N 352.5 210 382.5 210 {lab=#net2}
N 732.5 90 752.5 90 {lab=#net2}
N 752.5 30 752.5 90 {lab=#net2}
N 732.5 330 752.5 330 {lab=#net2}
N 752.5 90 752.5 330 {lab=#net2}
N 442.5 130 792.5 130 {lab=x0_s8}
N 352.5 270 442.5 270 {lab=x0_b0_f}
N 382.5 450 402.5 450 {lab=#net2}
N 382.5 30 752.5 30 {lab=#net2}
N 382.5 30 382.5 210 {lab=#net2}
N 382.5 210 382.5 450 {lab=#net2}
N 582.5 60 582.5 480 {lab=x0_b0_f_not}
N 582.5 480 582.5 510 {lab=x0_b0_f_not}
N 442.5 370 792.5 370 {lab=x0_s8_not}
N 562.5 0 592.5 0 {lab=#net1}
N 752.5 30 802.5 30 {lab=#net2}
N 280 -0 287.5 -0 {lab=#net1}
N 280 40 287.5 40 {lab=#net1}
N 287.5 0 287.5 40 {lab=#net1}
N 280 20 295 20 {lab=#net2}
N 280 60 295 60 {lab=#net2}
N 295 20 295 60 {lab=#net2}
N 287.5 -0 562.5 0 {lab=#net1}
N 352.5 40 352.5 210 {lab=#net2}
N 280 -690 290 -690 {lab=x0_c0_b}
N 280 -670 290 -670 {lab=x0_c0_b_not}
N 280 -450 290 -450 {lab=b0_r3_b}
N 280 -430 290 -430 {lab=b0_r3_b_not}
N 280 -370 290 -370 {lab=b0_r4_b}
N 280 -350 290 -350 {lab=b0_r4_b_not}
N 280 -290 290 -290 {lab=b0_r5_b}
N 280 -270 290 -270 {lab=b0_r5_b_not}
N 280 -210 290 -210 {lab=b0_r6_b}
N 280 -190 290 -190 {lab=b0_r6_b_not}
N 280 -130 290 -130 {lab=b0_r7_b}
N 280 -110 290 -110 {lab=b0_r7_b_not}
N 280 -50 290 -50 {lab=x0_a7_b}
N 280 -30 290 -30 {lab=x0_a7_b_not}
N 280 -410 290 -410 {lab=x0_s3}
N 280 -390 290 -390 {lab=x0_s3_not}
N 280 -330 290 -330 {lab=x0_s4}
N 280 -310 290 -310 {lab=x0_s4_not}
N 280 -250 290 -250 {lab=x0_s5}
N 280 -230 290 -230 {lab=x0_s5_not}
N 280 -170 290 -170 {lab=x0_s6}
N 280 -150 290 -150 {lab=x0_s6_not}
N 280 -90 290 -90 {lab=x0_s7}
N 280 -70 290 -70 {lab=x0_s7_not}
N 2522.5 80 2632.5 80 {lab=x1_b0_f_not}
N 2382.5 140 2632.5 140 {lab=x1_s8}
N 2382.5 110 2432.5 110 {lab=vss}
N 2582.5 110 2632.5 110 {lab=vdd}
N 2382.5 200 2632.5 200 {lab=x1_s8}
N 2382.5 260 2632.5 260 {lab=x1_b0_f}
N 2382.5 230 2432.5 230 {lab=vss}
N 2582.5 230 2632.5 230 {lab=vdd}
N 2382.5 150 2382.5 200 {lab=x1_s8}
N 2342.5 110 2342.5 170 {lab=#net3}
N 2502.5 170 2672.5 170 {lab=#net3}
N 2672.5 170 2672.5 230 {lab=#net3}
N 2382.5 320 2632.5 320 {lab=x1_b0_f}
N 2382.5 380 2632.5 380 {lab=x1_s8_not}
N 2382.5 350 2432.5 350 {lab=vss}
N 2582.5 350 2632.5 350 {lab=vdd}
N 2382.5 440 2632.5 440 {lab=x1_s8_not}
N 2522.5 500 2632.5 500 {lab=x1_b0_f_not}
N 2382.5 470 2432.5 470 {lab=vss}
N 2582.5 470 2632.5 470 {lab=vdd}
N 2382.5 390 2382.5 440 {lab=x1_s8_not}
N 2342.5 350 2342.5 410 {lab=#net3}
N 2502.5 410 2672.5 410 {lab=#net3}
N 2672.5 410 2672.5 470 {lab=#net3}
N 2382.5 290 2382.5 320 {lab=x1_b0_f}
N 2322.5 230 2342.5 230 {lab=#net4}
N 2292.5 530 2522.5 530 {lab=x1_b0_f_not}
N 2502.5 20 2502.5 170 {lab=#net3}
N 2502.5 170 2502.5 410 {lab=#net3}
N 2292.5 230 2322.5 230 {lab=#net4}
N 2672.5 110 2692.5 110 {lab=#net4}
N 2692.5 50 2692.5 110 {lab=#net4}
N 2672.5 350 2692.5 350 {lab=#net4}
N 2692.5 110 2692.5 350 {lab=#net4}
N 2382.5 150 2732.5 150 {lab=x1_s8}
N 2292.5 290 2382.5 290 {lab=x1_b0_f}
N 2322.5 470 2342.5 470 {lab=#net4}
N 2322.5 50 2692.5 50 {lab=#net4}
N 2322.5 50 2322.5 230 {lab=#net4}
N 2322.5 230 2322.5 470 {lab=#net4}
N 2522.5 80 2522.5 500 {lab=x1_b0_f_not}
N 2522.5 500 2522.5 530 {lab=x1_b0_f_not}
N 2382.5 390 2732.5 390 {lab=x1_s8_not}
N 2502.5 20 2532.5 20 {lab=#net3}
N 2692.5 50 2742.5 50 {lab=#net4}
N 2220 20 2227.5 20 {lab=#net3}
N 2220 60 2227.5 60 {lab=#net3}
N 2227.5 20 2227.5 60 {lab=#net3}
N 2220 40 2235 40 {lab=#net4}
N 2220 80 2235 80 {lab=#net4}
N 2235 40 2235 80 {lab=#net4}
N 2227.5 20 2502.5 20 {lab=#net3}
N 2292.5 60 2292.5 230 {lab=#net4}
N 2220 -630 2230 -630 {lab=p2}
N 2220 -610 2230 -610 {lab=p2_not}
N 2220 -670 2230 -670 {lab=x1_c0_b}
N 2220 -650 2230 -650 {lab=x1_c0_b_not}
N 2220 -590 2230 -590 {lab=b2_r0_b}
N 2220 -570 2230 -570 {lab=b2_r0_b_not}
N 2220 -510 2230 -510 {lab=b2_r1_b}
N 2220 -490 2230 -490 {lab=b2_r1_b_not}
N 2220 -550 2230 -550 {lab=x1_s1}
N 2220 -530 2230 -530 {lab=x1_s1_not}
N 2220 -470 2230 -470 {lab=x1_s2}
N 2220 -450 2230 -450 {lab=x1_s2_not}
N 2220 -430 2230 -430 {lab=b2_r2_b}
N 2220 -410 2230 -410 {lab=b2_r2_b_not}
N 2220 -350 2230 -350 {lab=b2_r3_b}
N 2220 -330 2230 -330 {lab=b2_r3_b_not}
N 2220 -270 2230 -270 {lab=b2_r4_b}
N 2220 -250 2230 -250 {lab=b2_r4_b_not}
N 2220 -190 2230 -190 {lab=b2_r5_b}
N 2220 -170 2230 -170 {lab=b2_r5_b_not}
N 2220 -110 2230 -110 {lab=b2_r6_b}
N 2220 -90 2230 -90 {lab=b2_r6_b_not}
N 2220 -30 2230 -30 {lab=b2_r7_b}
N 2220 -10 2230 -10 {lab=b2_r7_b_not}
N 2220 -390 2230 -390 {lab=x1_s3}
N 2220 -370 2230 -370 {lab=x1_s3_not}
N 2220 -310 2230 -310 {lab=x1_s4}
N 2220 -290 2230 -290 {lab=x1_s4_not}
N 2220 -230 2230 -230 {lab=x1_s5}
N 2220 -210 2230 -210 {lab=x1_s5_not}
N 2220 -150 2230 -150 {lab=x1_s6}
N 2220 -130 2230 -130 {lab=x1_s6_not}
N 2220 -70 2230 -70 {lab=x1_s7}
N 2220 -50 2230 -50 {lab=x1_s7_not}
N 3140 -732.5 3140 -722.5 {lab=vdd}
N 2980 -532.5 2990 -532.5 {lab=b3_c0}
N 2980 -512.5 2990 -512.5 {lab=b3_c0_not}
N 2980 -612.5 2990 -612.5 {lab=a0}
N 2980 -592.5 2990 -592.5 {lab=a0_not}
N 2980 -572.5 2990 -572.5 {lab=b3}
N 2980 -552.5 2990 -552.5 {lab=b3_not}
N 3290 -532.5 3300 -532.5 {lab=b3_r0}
N 3290 -512.5 3300 -512.5 {lab=b3_r0_not}
N 3130 -402.5 3140 -402.5 {lab=vss}
N 3140 -367.5 3140 -357.5 {lab=vdd}
N 2980 -167.5 2990 -167.5 {lab=b3_c1}
N 2980 -147.5 2990 -147.5 {lab=b3_c1_not}
N 2980 -247.5 2990 -247.5 {lab=a1}
N 2980 -227.5 2990 -227.5 {lab=a1_not}
N 2980 -207.5 2990 -207.5 {lab=b3}
N 2980 -187.5 2990 -187.5 {lab=b3_not}
N 3290 -167.5 3300 -167.5 {lab=b3_r1}
N 3290 -147.5 3300 -147.5 {lab=b3_r1_not}
N 3130 -37.5 3140 -37.5 {lab=vss}
N 3140 -2.5 3140 7.5 {lab=vdd}
N 2980 197.5 2990 197.5 {lab=b3_c2}
N 2980 217.5 2990 217.5 {lab=b3_c2_not}
N 2980 117.5 2990 117.5 {lab=a2}
N 2980 137.5 2990 137.5 {lab=a2_not}
N 2980 157.5 2990 157.5 {lab=b3}
N 2980 177.5 2990 177.5 {lab=b3_not}
N 3290 197.5 3300 197.5 {lab=b3_r2}
N 3290 217.5 3300 217.5 {lab=b3_r2_not}
N 3130 327.5 3140 327.5 {lab=vss}
N 3140 362.5 3140 372.5 {lab=vdd}
N 2980 562.5 2990 562.5 {lab=b3_c3}
N 2980 582.5 2990 582.5 {lab=b3_c3_not}
N 2980 482.5 2990 482.5 {lab=a3}
N 2980 502.5 2990 502.5 {lab=a3_not}
N 2980 522.5 2990 522.5 {lab=b3}
N 2980 542.5 2990 542.5 {lab=b3_not}
N 3290 562.5 3300 562.5 {lab=b3_r3}
N 3290 582.5 3300 582.5 {lab=b3_r3_not}
N 3130 692.5 3140 692.5 {lab=vss}
N 3140 740 3140 750 {lab=vdd}
N 2980 940 2990 940 {lab=b3_c4}
N 2980 960 2990 960 {lab=b3_c4_not}
N 2980 860 2990 860 {lab=a4}
N 2980 880 2990 880 {lab=a4_not}
N 2980 900 2990 900 {lab=b3}
N 2980 920 2990 920 {lab=b3_not}
N 3290 940 3300 940 {lab=b3_r4}
N 3290 960 3300 960 {lab=b3_r4_not}
N 3130 1070 3140 1070 {lab=vss}
N 3140 1105 3140 1115 {lab=vdd}
N 2980 1305 2990 1305 {lab=b3_c5}
N 2980 1325 2990 1325 {lab=b3_c5_not}
N 2980 1225 2990 1225 {lab=a5}
N 2980 1245 2990 1245 {lab=a5_not}
N 2980 1265 2990 1265 {lab=b3}
N 2980 1285 2990 1285 {lab=b3_not}
N 3290 1305 3300 1305 {lab=b3_r5}
N 3290 1325 3300 1325 {lab=b3_r5_not}
N 3130 1435 3140 1435 {lab=vss}
N 3140 1470 3140 1480 {lab=vdd}
N 2980 1670 2990 1670 {lab=b3_c6}
N 2980 1690 2990 1690 {lab=b3_c6_not}
N 2980 1590 2990 1590 {lab=a6}
N 2980 1610 2990 1610 {lab=a6_not}
N 2980 1630 2990 1630 {lab=b3}
N 2980 1650 2990 1650 {lab=b3_not}
N 3290 1670 3300 1670 {lab=b3_r6}
N 3290 1690 3300 1690 {lab=b3_r6_not}
N 3130 1800 3140 1800 {lab=vss}
N 3140 1835 3140 1845 {lab=vdd}
N 2980 2035 2990 2035 {lab=b3_c7}
N 2980 2055 2990 2055 {lab=b3_c7_not}
N 2980 1955 2990 1955 {lab=a7}
N 2980 1975 2990 1975 {lab=a7_not}
N 2980 1995 2990 1995 {lab=b3}
N 2980 2015 2990 2015 {lab=b3_not}
N 3290 2035 3300 2035 {lab=b3_r7}
N 3290 2055 3300 2055 {lab=b3_r7_not}
N 3130 2165 3140 2165 {lab=vss}
N 3290 -572.5 3300 -572.5 {lab=b3_q0}
N 3290 -552.5 3300 -552.5 {lab=b3_q0_not}
N 3290 -612.5 3300 -612.5 {lab=b3_p0}
N 3290 -592.5 3300 -592.5 {lab=b3_p0_not}
N 3290 -207.5 3300 -207.5 {lab=b3_q1}
N 3290 -187.5 3300 -187.5 {lab=b3_q1_not}
N 3290 -247.5 3300 -247.5 {lab=b3_p1}
N 3290 -227.5 3300 -227.5 {lab=b3_p1_not}
N 3290 157.5 3300 157.5 {lab=b3_q2}
N 3290 177.5 3300 177.5 {lab=b3_q2_not}
N 3290 117.5 3300 117.5 {lab=b3_p2}
N 3290 137.5 3300 137.5 {lab=b3_p2_not}
N 3290 522.5 3300 522.5 {lab=b3_q3}
N 3290 542.5 3300 542.5 {lab=b3_q3_not}
N 3290 482.5 3300 482.5 {lab=b3_p3}
N 3290 502.5 3300 502.5 {lab=b3_p3_not}
N 3290 900 3300 900 {lab=b3_q4}
N 3290 920 3300 920 {lab=b3_q4_not}
N 3290 860 3300 860 {lab=b3_p4}
N 3290 880 3300 880 {lab=b3_p4_not}
N 3290 1265 3300 1265 {lab=b3_q5}
N 3290 1285 3300 1285 {lab=b3_q5_not}
N 3290 1225 3300 1225 {lab=b3_p5}
N 3290 1245 3300 1245 {lab=b3_p5_not}
N 3290 1630 3300 1630 {lab=b3_q6}
N 3290 1650 3300 1650 {lab=b3_q6_not}
N 3290 1590 3300 1590 {lab=b3_p6}
N 3290 1610 3300 1610 {lab=b3_p6_not}
N 3290 1995 3300 1995 {lab=b3_q7}
N 3290 2015 3300 2015 {lab=b3_q7_not}
N 3290 1955 3300 1955 {lab=b3_p7}
N 3290 1975 3300 1975 {lab=b3_p7_not}
N 3875 -727.5 3875 -707.5 {lab=vdd}
N 3875 102.5 3875 122.5 {lab=vss}
N 3715 -597.5 3725 -597.5 {lab=b3_r0}
N 3715 -577.5 3725 -577.5 {lab=b3_r0_not}
N 3715 -637.5 3725 -637.5 {lab=x1_s1}
N 3715 -617.5 3725 -617.5 {lab=x1_s1_not}
N 3705 -657.5 3725 -657.5 {lab=x2_c0_f_not}
N 3705 -677.5 3725 -677.5 {lab=x2_c0_f}
N 3715 -517.5 3725 -517.5 {lab=b3_r1}
N 3715 -497.5 3725 -497.5 {lab=b3_r1_not}
N 3715 -557.5 3725 -557.5 {lab=x1_s2}
N 3715 -537.5 3725 -537.5 {lab=x1_s2_not}
N 3715 -437.5 3725 -437.5 {lab=b3_r2}
N 3715 -417.5 3725 -417.5 {lab=b3_r2_not}
N 3715 -477.5 3725 -477.5 {lab=x1_s3}
N 3715 -457.5 3725 -457.5 {lab=x1_s3_not}
N 3715 -357.5 3725 -357.5 {lab=b3_r3}
N 3715 -337.5 3725 -337.5 {lab=b3_r3_not}
N 3715 -397.5 3725 -397.5 {lab=x1_s4}
N 3715 -377.5 3725 -377.5 {lab=x1_s4_not}
N 3715 -277.5 3725 -277.5 {lab=b3_r4}
N 3715 -257.5 3725 -257.5 {lab=b3_r4_not}
N 3715 -317.5 3725 -317.5 {lab=x1_s5}
N 3715 -297.5 3725 -297.5 {lab=x1_s5_not}
N 3715 -197.5 3725 -197.5 {lab=b3_r5}
N 3715 -177.5 3725 -177.5 {lab=b3_r5_not}
N 3715 -237.5 3725 -237.5 {lab=x1_s6}
N 3715 -217.5 3725 -217.5 {lab=x1_s6_not}
N 3715 -117.5 3725 -117.5 {lab=b3_r6}
N 3715 -97.5 3725 -97.5 {lab=b3_r6_not}
N 3715 -157.5 3725 -157.5 {lab=x1_s7}
N 3715 -137.5 3725 -137.5 {lab=x1_s7_not}
N 3715 -37.5 3725 -37.5 {lab=b3_r7}
N 3715 -17.5 3725 -17.5 {lab=b3_r7_not}
N 3715 -77.5 3725 -77.5 {lab=x1_s8}
N 3715 -57.5 3725 -57.5 {lab=x1_s8_not}
N 4327.5 72.5 4437.5 72.5 {lab=x2_b0_f_not}
N 4187.5 132.5 4437.5 132.5 {lab=x2_s8}
N 4187.5 102.5 4237.5 102.5 {lab=vss}
N 4387.5 102.5 4437.5 102.5 {lab=vdd}
N 4187.5 192.5 4437.5 192.5 {lab=x2_s8}
N 4187.5 252.5 4437.5 252.5 {lab=x2_b0_f}
N 4187.5 222.5 4237.5 222.5 {lab=vss}
N 4387.5 222.5 4437.5 222.5 {lab=vdd}
N 4187.5 142.5 4187.5 192.5 {lab=x2_s8}
N 4147.5 102.5 4147.5 162.5 {lab=#net5}
N 4307.5 162.5 4477.5 162.5 {lab=#net5}
N 4477.5 162.5 4477.5 222.5 {lab=#net5}
N 4187.5 312.5 4437.5 312.5 {lab=x2_b0_f}
N 4187.5 372.5 4437.5 372.5 {lab=x2_s8_not}
N 4187.5 342.5 4237.5 342.5 {lab=vss}
N 4387.5 342.5 4437.5 342.5 {lab=vdd}
N 4187.5 432.5 4437.5 432.5 {lab=x2_s8_not}
N 4327.5 492.5 4437.5 492.5 {lab=x2_b0_f_not}
N 4187.5 462.5 4237.5 462.5 {lab=vss}
N 4387.5 462.5 4437.5 462.5 {lab=vdd}
N 4187.5 382.5 4187.5 432.5 {lab=x2_s8_not}
N 4147.5 342.5 4147.5 402.5 {lab=#net5}
N 4307.5 402.5 4477.5 402.5 {lab=#net5}
N 4477.5 402.5 4477.5 462.5 {lab=#net5}
N 4187.5 282.5 4187.5 312.5 {lab=x2_b0_f}
N 4127.5 222.5 4147.5 222.5 {lab=#net6}
N 4097.5 522.5 4327.5 522.5 {lab=x2_b0_f_not}
N 4307.5 12.5 4307.5 162.5 {lab=#net5}
N 4307.5 162.5 4307.5 402.5 {lab=#net5}
N 4097.5 222.5 4127.5 222.5 {lab=#net6}
N 4477.5 102.5 4497.5 102.5 {lab=#net6}
N 4497.5 42.5 4497.5 102.5 {lab=#net6}
N 4477.5 342.5 4497.5 342.5 {lab=#net6}
N 4497.5 102.5 4497.5 342.5 {lab=#net6}
N 4187.5 142.5 4537.5 142.5 {lab=x2_s8}
N 4097.5 282.5 4187.5 282.5 {lab=x2_b0_f}
N 4127.5 462.5 4147.5 462.5 {lab=#net6}
N 4127.5 42.5 4497.5 42.5 {lab=#net6}
N 4127.5 42.5 4127.5 222.5 {lab=#net6}
N 4127.5 222.5 4127.5 462.5 {lab=#net6}
N 4327.5 72.5 4327.5 492.5 {lab=x2_b0_f_not}
N 4327.5 492.5 4327.5 522.5 {lab=x2_b0_f_not}
N 4187.5 382.5 4537.5 382.5 {lab=x2_s8_not}
N 4307.5 12.5 4337.5 12.5 {lab=#net5}
N 4497.5 42.5 4547.5 42.5 {lab=#net6}
N 4025 12.5 4032.5 12.5 {lab=#net5}
N 4025 52.5 4032.5 52.5 {lab=#net5}
N 4032.5 12.5 4032.5 52.5 {lab=#net5}
N 4025 32.5 4040 32.5 {lab=#net6}
N 4025 72.5 4040 72.5 {lab=#net6}
N 4040 32.5 4040 72.5 {lab=#net6}
N 4032.5 12.5 4307.5 12.5 {lab=#net5}
N 4097.5 52.5 4097.5 222.5 {lab=#net6}
N 4025 -637.5 4035 -637.5 {lab=p3}
N 4025 -617.5 4035 -617.5 {lab=p3_not}
N 4025 -677.5 4035 -677.5 {lab=x2_c0_b}
N 4025 -657.5 4035 -657.5 {lab=x2_c0_b_not}
N 4025 -597.5 4035 -597.5 {lab=b3_r0_b}
N 4025 -577.5 4035 -577.5 {lab=b3_r0_b_not}
N 4025 -517.5 4035 -517.5 {lab=b3_r1_b}
N 4025 -497.5 4035 -497.5 {lab=b3_r1_b_not}
N 4025 -557.5 4035 -557.5 {lab=x2_s1}
N 4025 -537.5 4035 -537.5 {lab=x2_s1_not}
N 4025 -477.5 4035 -477.5 {lab=x2_s2}
N 4025 -457.5 4035 -457.5 {lab=x2_s2_not}
N 4025 -437.5 4035 -437.5 {lab=b3_r2_b}
N 4025 -417.5 4035 -417.5 {lab=b3_r2_b_not}
N 4025 -357.5 4035 -357.5 {lab=b3_r3_b}
N 4025 -337.5 4035 -337.5 {lab=b3_r3_b_not}
N 4025 -277.5 4035 -277.5 {lab=b3_r4_b}
N 4025 -257.5 4035 -257.5 {lab=b3_r4_b_not}
N 4025 -197.5 4035 -197.5 {lab=b3_r5_b}
N 4025 -177.5 4035 -177.5 {lab=b3_r5_b_not}
N 4025 -117.5 4035 -117.5 {lab=b3_r6_b}
N 4025 -97.5 4035 -97.5 {lab=b3_r6_b_not}
N 4025 -37.5 4035 -37.5 {lab=b3_r7_b}
N 4025 -17.5 4035 -17.5 {lab=b3_r7_b_not}
N 4025 -397.5 4035 -397.5 {lab=x2_s3}
N 4025 -377.5 4035 -377.5 {lab=x2_s3_not}
N 4025 -317.5 4035 -317.5 {lab=x2_s4}
N 4025 -297.5 4035 -297.5 {lab=x2_s4_not}
N 4025 -237.5 4035 -237.5 {lab=x2_s5}
N 4025 -217.5 4035 -217.5 {lab=x2_s5_not}
N 4025 -157.5 4035 -157.5 {lab=x2_s6}
N 4025 -137.5 4035 -137.5 {lab=x2_s6_not}
N 4025 -77.5 4035 -77.5 {lab=x2_s7}
N 4025 -57.5 4035 -57.5 {lab=x2_s7_not}
N 5002.5 -757.5 5002.5 -747.5 {lab=vdd}
N 4842.5 -557.5 4852.5 -557.5 {lab=b4_c0}
N 4842.5 -537.5 4852.5 -537.5 {lab=b4_c0_not}
N 4842.5 -637.5 4852.5 -637.5 {lab=a0}
N 4842.5 -617.5 4852.5 -617.5 {lab=a0_not}
N 4842.5 -597.5 4852.5 -597.5 {lab=b4}
N 4842.5 -577.5 4852.5 -577.5 {lab=b4_not}
N 5152.5 -557.5 5162.5 -557.5 {lab=b4_r0}
N 5152.5 -537.5 5162.5 -537.5 {lab=b4_r0_not}
N 4992.5 -427.5 5002.5 -427.5 {lab=vss}
N 5002.5 -392.5 5002.5 -382.5 {lab=vdd}
N 4842.5 -192.5 4852.5 -192.5 {lab=b4_c1}
N 4842.5 -172.5 4852.5 -172.5 {lab=b4_c1_not}
N 4842.5 -272.5 4852.5 -272.5 {lab=a1}
N 4842.5 -252.5 4852.5 -252.5 {lab=a1_not}
N 4842.5 -232.5 4852.5 -232.5 {lab=b4}
N 4842.5 -212.5 4852.5 -212.5 {lab=b4_not}
N 5152.5 -192.5 5162.5 -192.5 {lab=b4_r1}
N 5152.5 -172.5 5162.5 -172.5 {lab=b4_r1_not}
N 4992.5 -62.5 5002.5 -62.5 {lab=vss}
N 5002.5 -27.5 5002.5 -17.5 {lab=vdd}
N 4842.5 172.5 4852.5 172.5 {lab=b4_c2}
N 4842.5 192.5 4852.5 192.5 {lab=b4_c2_not}
N 4842.5 92.5 4852.5 92.5 {lab=a2}
N 4842.5 112.5 4852.5 112.5 {lab=a2_not}
N 4842.5 132.5 4852.5 132.5 {lab=b4}
N 4842.5 152.5 4852.5 152.5 {lab=b4_not}
N 5152.5 172.5 5162.5 172.5 {lab=b4_r2}
N 5152.5 192.5 5162.5 192.5 {lab=b4_r2_not}
N 4992.5 302.5 5002.5 302.5 {lab=vss}
N 5002.5 337.5 5002.5 347.5 {lab=vdd}
N 4842.5 537.5 4852.5 537.5 {lab=b4_c3}
N 4842.5 557.5 4852.5 557.5 {lab=b4_c3_not}
N 4842.5 457.5 4852.5 457.5 {lab=a3}
N 4842.5 477.5 4852.5 477.5 {lab=a3_not}
N 4842.5 497.5 4852.5 497.5 {lab=b4}
N 4842.5 517.5 4852.5 517.5 {lab=b4_not}
N 5152.5 537.5 5162.5 537.5 {lab=b4_r3}
N 5152.5 557.5 5162.5 557.5 {lab=b4_r3_not}
N 4992.5 667.5 5002.5 667.5 {lab=vss}
N 5002.5 715 5002.5 725 {lab=vdd}
N 4842.5 915 4852.5 915 {lab=b4_c4}
N 4842.5 935 4852.5 935 {lab=b4_c4_not}
N 4842.5 835 4852.5 835 {lab=a4}
N 4842.5 855 4852.5 855 {lab=a4_not}
N 4842.5 875 4852.5 875 {lab=b4}
N 4842.5 895 4852.5 895 {lab=b4_not}
N 5152.5 915 5162.5 915 {lab=b4_r4}
N 5152.5 935 5162.5 935 {lab=b4_r4_not}
N 4992.5 1045 5002.5 1045 {lab=vss}
N 5002.5 1080 5002.5 1090 {lab=vdd}
N 4842.5 1280 4852.5 1280 {lab=b4_c5}
N 4842.5 1300 4852.5 1300 {lab=b4_c5_not}
N 4842.5 1200 4852.5 1200 {lab=a5}
N 4842.5 1220 4852.5 1220 {lab=a5_not}
N 4842.5 1240 4852.5 1240 {lab=b4}
N 4842.5 1260 4852.5 1260 {lab=b4_not}
N 5152.5 1280 5162.5 1280 {lab=b4_r5}
N 5152.5 1300 5162.5 1300 {lab=b4_r5_not}
N 4992.5 1410 5002.5 1410 {lab=vss}
N 5002.5 1445 5002.5 1455 {lab=vdd}
N 4842.5 1645 4852.5 1645 {lab=b4_c6}
N 4842.5 1665 4852.5 1665 {lab=b4_c6_not}
N 4842.5 1565 4852.5 1565 {lab=a6}
N 4842.5 1585 4852.5 1585 {lab=a6_not}
N 4842.5 1605 4852.5 1605 {lab=b4}
N 4842.5 1625 4852.5 1625 {lab=b4_not}
N 5152.5 1645 5162.5 1645 {lab=b4_r6}
N 5152.5 1665 5162.5 1665 {lab=b4_r6_not}
N 4992.5 1775 5002.5 1775 {lab=vss}
N 5002.5 1810 5002.5 1820 {lab=vdd}
N 4842.5 2010 4852.5 2010 {lab=b4_c7}
N 4842.5 2030 4852.5 2030 {lab=b4_c7_not}
N 4842.5 1930 4852.5 1930 {lab=a7}
N 4842.5 1950 4852.5 1950 {lab=a7_not}
N 4842.5 1970 4852.5 1970 {lab=b4}
N 4842.5 1990 4852.5 1990 {lab=b4_not}
N 5152.5 2010 5162.5 2010 {lab=b4_r7}
N 5152.5 2030 5162.5 2030 {lab=b4_r7_not}
N 4992.5 2140 5002.5 2140 {lab=vss}
N 5152.5 -597.5 5162.5 -597.5 {lab=b4_q0}
N 5152.5 -577.5 5162.5 -577.5 {lab=b4_q0_not}
N 5152.5 -637.5 5162.5 -637.5 {lab=b4_p0}
N 5152.5 -617.5 5162.5 -617.5 {lab=b4_p0_not}
N 5152.5 -232.5 5162.5 -232.5 {lab=b4_q1}
N 5152.5 -212.5 5162.5 -212.5 {lab=b4_q1_not}
N 5152.5 -272.5 5162.5 -272.5 {lab=b4_p1}
N 5152.5 -252.5 5162.5 -252.5 {lab=b4_p1_not}
N 5152.5 132.5 5162.5 132.5 {lab=b4_q2}
N 5152.5 152.5 5162.5 152.5 {lab=b4_q2_not}
N 5152.5 92.5 5162.5 92.5 {lab=b4_p2}
N 5152.5 112.5 5162.5 112.5 {lab=b4_p2_not}
N 5152.5 497.5 5162.5 497.5 {lab=b4_q3}
N 5152.5 517.5 5162.5 517.5 {lab=b4_q3_not}
N 5152.5 457.5 5162.5 457.5 {lab=b4_p3}
N 5152.5 477.5 5162.5 477.5 {lab=b4_p3_not}
N 5152.5 875 5162.5 875 {lab=b4_q4}
N 5152.5 895 5162.5 895 {lab=b4_q4_not}
N 5152.5 835 5162.5 835 {lab=b4_p4}
N 5152.5 855 5162.5 855 {lab=b4_p4_not}
N 5152.5 1240 5162.5 1240 {lab=b4_q5}
N 5152.5 1260 5162.5 1260 {lab=b4_q5_not}
N 5152.5 1200 5162.5 1200 {lab=b4_p5}
N 5152.5 1220 5162.5 1220 {lab=b4_p5_not}
N 5152.5 1605 5162.5 1605 {lab=b4_q6}
N 5152.5 1625 5162.5 1625 {lab=b4_q6_not}
N 5152.5 1565 5162.5 1565 {lab=b4_p6}
N 5152.5 1585 5162.5 1585 {lab=b4_p6_not}
N 5152.5 1970 5162.5 1970 {lab=b4_q7}
N 5152.5 1990 5162.5 1990 {lab=b4_q7_not}
N 5152.5 1930 5162.5 1930 {lab=b4_p7}
N 5152.5 1950 5162.5 1950 {lab=b4_p7_not}
N 5732.5 -757.5 5732.5 -737.5 {lab=vdd}
N 5732.5 72.5 5732.5 92.5 {lab=vss}
N 5572.5 -627.5 5582.5 -627.5 {lab=b4_r0}
N 5572.5 -607.5 5582.5 -607.5 {lab=b4_r0_not}
N 5572.5 -667.5 5582.5 -667.5 {lab=x2_s1}
N 5572.5 -647.5 5582.5 -647.5 {lab=x2_s1_not}
N 5562.5 -687.5 5582.5 -687.5 {lab=x3_c0_f_not}
N 5562.5 -707.5 5582.5 -707.5 {lab=x3_c0_f}
N 5572.5 -547.5 5582.5 -547.5 {lab=b4_r1}
N 5572.5 -527.5 5582.5 -527.5 {lab=b4_r1_not}
N 5572.5 -587.5 5582.5 -587.5 {lab=x2_s2}
N 5572.5 -567.5 5582.5 -567.5 {lab=x2_s2_not}
N 5572.5 -467.5 5582.5 -467.5 {lab=b4_r2}
N 5572.5 -447.5 5582.5 -447.5 {lab=b4_r2_not}
N 5572.5 -507.5 5582.5 -507.5 {lab=x2_s3}
N 5572.5 -487.5 5582.5 -487.5 {lab=x2_s3_not}
N 5572.5 -387.5 5582.5 -387.5 {lab=b4_r3}
N 5572.5 -367.5 5582.5 -367.5 {lab=b4_r3_not}
N 5572.5 -427.5 5582.5 -427.5 {lab=x2_s4}
N 5572.5 -407.5 5582.5 -407.5 {lab=x2_s4_not}
N 5572.5 -307.5 5582.5 -307.5 {lab=b4_r4}
N 5572.5 -287.5 5582.5 -287.5 {lab=b4_r4_not}
N 5572.5 -347.5 5582.5 -347.5 {lab=x2_s5}
N 5572.5 -327.5 5582.5 -327.5 {lab=x2_s5_not}
N 5572.5 -227.5 5582.5 -227.5 {lab=b4_r5}
N 5572.5 -207.5 5582.5 -207.5 {lab=b4_r5_not}
N 5572.5 -267.5 5582.5 -267.5 {lab=x2_s6}
N 5572.5 -247.5 5582.5 -247.5 {lab=x2_s6_not}
N 5572.5 -147.5 5582.5 -147.5 {lab=b4_r6}
N 5572.5 -127.5 5582.5 -127.5 {lab=b4_r6_not}
N 5572.5 -187.5 5582.5 -187.5 {lab=x2_s7}
N 5572.5 -167.5 5582.5 -167.5 {lab=x2_s7_not}
N 5572.5 -67.5 5582.5 -67.5 {lab=b4_r7}
N 5572.5 -47.5 5582.5 -47.5 {lab=b4_r7_not}
N 5572.5 -107.5 5582.5 -107.5 {lab=x2_s8}
N 5572.5 -87.5 5582.5 -87.5 {lab=x2_s8_not}
N 6185 42.5 6295 42.5 {lab=x3_b0_f_not}
N 6045 102.5 6295 102.5 {lab=x3_s8}
N 6045 72.5 6095 72.5 {lab=vss}
N 6245 72.5 6295 72.5 {lab=vdd}
N 6045 162.5 6295 162.5 {lab=x3_s8}
N 6045 222.5 6295 222.5 {lab=x3_b0_f}
N 6045 192.5 6095 192.5 {lab=vss}
N 6245 192.5 6295 192.5 {lab=vdd}
N 6045 112.5 6045 162.5 {lab=x3_s8}
N 6005 72.5 6005 132.5 {lab=#net7}
N 6165 132.5 6335 132.5 {lab=#net7}
N 6335 132.5 6335 192.5 {lab=#net7}
N 6045 282.5 6295 282.5 {lab=x3_b0_f}
N 6045 342.5 6295 342.5 {lab=x3_s8_not}
N 6045 312.5 6095 312.5 {lab=vss}
N 6245 312.5 6295 312.5 {lab=vdd}
N 6045 402.5 6295 402.5 {lab=x3_s8_not}
N 6185 462.5 6295 462.5 {lab=x3_b0_f_not}
N 6045 432.5 6095 432.5 {lab=vss}
N 6245 432.5 6295 432.5 {lab=vdd}
N 6045 352.5 6045 402.5 {lab=x3_s8_not}
N 6005 312.5 6005 372.5 {lab=#net7}
N 6165 372.5 6335 372.5 {lab=#net7}
N 6335 372.5 6335 432.5 {lab=#net7}
N 6045 252.5 6045 282.5 {lab=x3_b0_f}
N 5985 192.5 6005 192.5 {lab=#net8}
N 5955 492.5 6185 492.5 {lab=x3_b0_f_not}
N 6165 -17.5 6165 132.5 {lab=#net7}
N 6165 132.5 6165 372.5 {lab=#net7}
N 5955 192.5 5985 192.5 {lab=#net8}
N 6335 72.5 6355 72.5 {lab=#net8}
N 6355 12.5 6355 72.5 {lab=#net8}
N 6335 312.5 6355 312.5 {lab=#net8}
N 6355 72.5 6355 312.5 {lab=#net8}
N 6045 112.5 6395 112.5 {lab=x3_s8}
N 5955 252.5 6045 252.5 {lab=x3_b0_f}
N 5985 432.5 6005 432.5 {lab=#net8}
N 5985 12.5 6355 12.5 {lab=#net8}
N 5985 12.5 5985 192.5 {lab=#net8}
N 5985 192.5 5985 432.5 {lab=#net8}
N 6185 42.5 6185 462.5 {lab=x3_b0_f_not}
N 6185 462.5 6185 492.5 {lab=x3_b0_f_not}
N 6045 352.5 6395 352.5 {lab=x3_s8_not}
N 6165 -17.5 6195 -17.5 {lab=#net7}
N 6355 12.5 6405 12.5 {lab=#net8}
N 5882.5 -17.5 5890 -17.5 {lab=#net7}
N 5882.5 22.5 5890 22.5 {lab=#net7}
N 5890 -17.5 5890 22.5 {lab=#net7}
N 5882.5 2.5 5897.5 2.5 {lab=#net8}
N 5882.5 42.5 5897.5 42.5 {lab=#net8}
N 5897.5 2.5 5897.5 42.5 {lab=#net8}
N 5890 -17.5 6165 -17.5 {lab=#net7}
N 5955 22.5 5955 192.5 {lab=#net8}
N 5882.5 -667.5 5892.5 -667.5 {lab=p4}
N 5882.5 -647.5 5892.5 -647.5 {lab=p4_not}
N 5882.5 -707.5 5892.5 -707.5 {lab=x3_c0_b}
N 5882.5 -687.5 5892.5 -687.5 {lab=x3_c0_b_not}
N 5882.5 -627.5 5892.5 -627.5 {lab=b4_r0_b}
N 5882.5 -607.5 5892.5 -607.5 {lab=b4_r0_b_not}
N 5882.5 -547.5 5892.5 -547.5 {lab=b4_r1_b}
N 5882.5 -527.5 5892.5 -527.5 {lab=b4_r1_b_not}
N 5882.5 -587.5 5892.5 -587.5 {lab=x3_s1}
N 5882.5 -567.5 5892.5 -567.5 {lab=x3_s1_not}
N 5882.5 -507.5 5892.5 -507.5 {lab=x3_s2}
N 5882.5 -487.5 5892.5 -487.5 {lab=x3_s2_not}
N 5882.5 -467.5 5892.5 -467.5 {lab=b4_r2_b}
N 5882.5 -447.5 5892.5 -447.5 {lab=b4_r2_b_not}
N 5882.5 -387.5 5892.5 -387.5 {lab=b4_r3_b}
N 5882.5 -367.5 5892.5 -367.5 {lab=b4_r3_b_not}
N 5882.5 -307.5 5892.5 -307.5 {lab=b4_r4_b}
N 5882.5 -287.5 5892.5 -287.5 {lab=b4_r4_b_not}
N 5882.5 -227.5 5892.5 -227.5 {lab=b4_r5_b}
N 5882.5 -207.5 5892.5 -207.5 {lab=b4_r5_b_not}
N 5882.5 -147.5 5892.5 -147.5 {lab=b4_r6_b}
N 5882.5 -127.5 5892.5 -127.5 {lab=b4_r6_b_not}
N 5882.5 -67.5 5892.5 -67.5 {lab=b4_r7_b}
N 5882.5 -47.5 5892.5 -47.5 {lab=b4_r7_b_not}
N 5882.5 -427.5 5892.5 -427.5 {lab=x3_s3}
N 5882.5 -407.5 5892.5 -407.5 {lab=x3_s3_not}
N 5882.5 -347.5 5892.5 -347.5 {lab=x3_s4}
N 5882.5 -327.5 5892.5 -327.5 {lab=x3_s4_not}
N 5882.5 -267.5 5892.5 -267.5 {lab=x3_s5}
N 5882.5 -247.5 5892.5 -247.5 {lab=x3_s5_not}
N 5882.5 -187.5 5892.5 -187.5 {lab=x3_s6}
N 5882.5 -167.5 5892.5 -167.5 {lab=x3_s6_not}
N 5882.5 -107.5 5892.5 -107.5 {lab=x3_s7}
N 5882.5 -87.5 5892.5 -87.5 {lab=x3_s7_not}
N 6902.5 -747.5 6902.5 -737.5 {lab=vdd}
N 6742.5 -547.5 6752.5 -547.5 {lab=b5_c0}
N 6742.5 -527.5 6752.5 -527.5 {lab=b5_c0_not}
N 6742.5 -627.5 6752.5 -627.5 {lab=a0}
N 6742.5 -607.5 6752.5 -607.5 {lab=a0_not}
N 6742.5 -587.5 6752.5 -587.5 {lab=b5}
N 6742.5 -567.5 6752.5 -567.5 {lab=b5_not}
N 7052.5 -547.5 7062.5 -547.5 {lab=b5_r0}
N 7052.5 -527.5 7062.5 -527.5 {lab=b5_r0_not}
N 6892.5 -417.5 6902.5 -417.5 {lab=vss}
N 6902.5 -382.5 6902.5 -372.5 {lab=vdd}
N 6742.5 -182.5 6752.5 -182.5 {lab=b5_c1}
N 6742.5 -162.5 6752.5 -162.5 {lab=b5_c1_not}
N 6742.5 -262.5 6752.5 -262.5 {lab=a1}
N 6742.5 -242.5 6752.5 -242.5 {lab=a1_not}
N 6742.5 -222.5 6752.5 -222.5 {lab=b5}
N 6742.5 -202.5 6752.5 -202.5 {lab=b5_not}
N 7052.5 -182.5 7062.5 -182.5 {lab=b5_r1}
N 7052.5 -162.5 7062.5 -162.5 {lab=b5_r1_not}
N 6892.5 -52.5 6902.5 -52.5 {lab=vss}
N 6902.5 -17.5 6902.5 -7.5 {lab=vdd}
N 6742.5 182.5 6752.5 182.5 {lab=b5_c2}
N 6742.5 202.5 6752.5 202.5 {lab=b5_c2_not}
N 6742.5 102.5 6752.5 102.5 {lab=a2}
N 6742.5 122.5 6752.5 122.5 {lab=a2_not}
N 6742.5 142.5 6752.5 142.5 {lab=b5}
N 6742.5 162.5 6752.5 162.5 {lab=b5_not}
N 7052.5 182.5 7062.5 182.5 {lab=b5_r2}
N 7052.5 202.5 7062.5 202.5 {lab=b5_r2_not}
N 6892.5 312.5 6902.5 312.5 {lab=vss}
N 6902.5 347.5 6902.5 357.5 {lab=vdd}
N 6742.5 547.5 6752.5 547.5 {lab=b5_c3}
N 6742.5 567.5 6752.5 567.5 {lab=b5_c3_not}
N 6742.5 467.5 6752.5 467.5 {lab=a3}
N 6742.5 487.5 6752.5 487.5 {lab=a3_not}
N 6742.5 507.5 6752.5 507.5 {lab=b5}
N 6742.5 527.5 6752.5 527.5 {lab=b5_not}
N 7052.5 547.5 7062.5 547.5 {lab=b5_r3}
N 7052.5 567.5 7062.5 567.5 {lab=b5_r3_not}
N 6892.5 677.5 6902.5 677.5 {lab=vss}
N 6902.5 725 6902.5 735 {lab=vdd}
N 6742.5 925 6752.5 925 {lab=b5_c4}
N 6742.5 945 6752.5 945 {lab=b5_c4_not}
N 6742.5 845 6752.5 845 {lab=a4}
N 6742.5 865 6752.5 865 {lab=a4_not}
N 6742.5 885 6752.5 885 {lab=b5}
N 6742.5 905 6752.5 905 {lab=b5_not}
N 7052.5 925 7062.5 925 {lab=b5_r4}
N 7052.5 945 7062.5 945 {lab=b5_r4_not}
N 6892.5 1055 6902.5 1055 {lab=vss}
N 6902.5 1090 6902.5 1100 {lab=vdd}
N 6742.5 1290 6752.5 1290 {lab=b5_c5}
N 6742.5 1310 6752.5 1310 {lab=b5_c5_not}
N 6742.5 1210 6752.5 1210 {lab=a5}
N 6742.5 1230 6752.5 1230 {lab=a5_not}
N 6742.5 1250 6752.5 1250 {lab=b5}
N 6742.5 1270 6752.5 1270 {lab=b5_not}
N 7052.5 1290 7062.5 1290 {lab=b5_r5}
N 7052.5 1310 7062.5 1310 {lab=b5_r5_not}
N 6892.5 1420 6902.5 1420 {lab=vss}
N 6902.5 1455 6902.5 1465 {lab=vdd}
N 6742.5 1655 6752.5 1655 {lab=b5_c6}
N 6742.5 1675 6752.5 1675 {lab=b5_c6_not}
N 6742.5 1575 6752.5 1575 {lab=a6}
N 6742.5 1595 6752.5 1595 {lab=a6_not}
N 6742.5 1615 6752.5 1615 {lab=b5}
N 6742.5 1635 6752.5 1635 {lab=b5_not}
N 7052.5 1655 7062.5 1655 {lab=b5_r6}
N 7052.5 1675 7062.5 1675 {lab=b5_r6_not}
N 6892.5 1785 6902.5 1785 {lab=vss}
N 6902.5 1820 6902.5 1830 {lab=vdd}
N 6742.5 2020 6752.5 2020 {lab=b5_c7}
N 6742.5 2040 6752.5 2040 {lab=b5_c7_not}
N 6742.5 1940 6752.5 1940 {lab=a7}
N 6742.5 1960 6752.5 1960 {lab=a7_not}
N 6742.5 1980 6752.5 1980 {lab=b5}
N 6742.5 2000 6752.5 2000 {lab=b5_not}
N 7052.5 2020 7062.5 2020 {lab=b5_r7}
N 7052.5 2040 7062.5 2040 {lab=b5_r7_not}
N 6892.5 2150 6902.5 2150 {lab=vss}
N 7052.5 -587.5 7062.5 -587.5 {lab=b5_q0}
N 7052.5 -567.5 7062.5 -567.5 {lab=b5_q0_not}
N 7052.5 -627.5 7062.5 -627.5 {lab=b5_p0}
N 7052.5 -607.5 7062.5 -607.5 {lab=b5_p0_not}
N 7052.5 -222.5 7062.5 -222.5 {lab=b5_q1}
N 7052.5 -202.5 7062.5 -202.5 {lab=b5_q1_not}
N 7052.5 -262.5 7062.5 -262.5 {lab=b5_p1}
N 7052.5 -242.5 7062.5 -242.5 {lab=b5_p1_not}
N 7052.5 142.5 7062.5 142.5 {lab=b5_q2}
N 7052.5 162.5 7062.5 162.5 {lab=b5_q2_not}
N 7052.5 102.5 7062.5 102.5 {lab=b5_p2}
N 7052.5 122.5 7062.5 122.5 {lab=b5_p2_not}
N 7052.5 507.5 7062.5 507.5 {lab=b5_q3}
N 7052.5 527.5 7062.5 527.5 {lab=b5_q3_not}
N 7052.5 467.5 7062.5 467.5 {lab=b5_p3}
N 7052.5 487.5 7062.5 487.5 {lab=b5_p3_not}
N 7052.5 885 7062.5 885 {lab=b5_q4}
N 7052.5 905 7062.5 905 {lab=b5_q4_not}
N 7052.5 845 7062.5 845 {lab=b5_p4}
N 7052.5 865 7062.5 865 {lab=b5_p4_not}
N 7052.5 1250 7062.5 1250 {lab=b5_q5}
N 7052.5 1270 7062.5 1270 {lab=b5_q5_not}
N 7052.5 1210 7062.5 1210 {lab=b5_p5}
N 7052.5 1230 7062.5 1230 {lab=b5_p5_not}
N 7052.5 1615 7062.5 1615 {lab=b5_q6}
N 7052.5 1635 7062.5 1635 {lab=b5_q6_not}
N 7052.5 1575 7062.5 1575 {lab=b5_p6}
N 7052.5 1595 7062.5 1595 {lab=b5_p6_not}
N 7052.5 1980 7062.5 1980 {lab=b5_q7}
N 7052.5 2000 7062.5 2000 {lab=b5_q7_not}
N 7052.5 1940 7062.5 1940 {lab=b5_p7}
N 7052.5 1960 7062.5 1960 {lab=b5_p7_not}
N 7760 -760 7760 -740 {lab=vdd}
N 7760 70 7760 90 {lab=vss}
N 7600 -630 7610 -630 {lab=b5_r0}
N 7600 -610 7610 -610 {lab=b5_r0_not}
N 7600 -670 7610 -670 {lab=x3_s1}
N 7600 -650 7610 -650 {lab=x3_s1_not}
N 7590 -690 7610 -690 {lab=x4_c0_f_not}
N 7590 -710 7610 -710 {lab=x4_c0_f}
N 7600 -550 7610 -550 {lab=b5_r1}
N 7600 -530 7610 -530 {lab=b5_r1_not}
N 7600 -590 7610 -590 {lab=x3_s2}
N 7600 -570 7610 -570 {lab=x3_s2_not}
N 7600 -470 7610 -470 {lab=b5_r2}
N 7600 -450 7610 -450 {lab=b5_r2_not}
N 7600 -510 7610 -510 {lab=x3_s3}
N 7600 -490 7610 -490 {lab=x3_s3_not}
N 7600 -390 7610 -390 {lab=b5_r3}
N 7600 -370 7610 -370 {lab=b5_r3_not}
N 7600 -430 7610 -430 {lab=x3_s4}
N 7600 -410 7610 -410 {lab=x3_s4_not}
N 7600 -310 7610 -310 {lab=b5_r4}
N 7600 -290 7610 -290 {lab=b5_r4_not}
N 7600 -350 7610 -350 {lab=x3_s5}
N 7600 -330 7610 -330 {lab=x3_s5_not}
N 7600 -230 7610 -230 {lab=b5_r5}
N 7600 -210 7610 -210 {lab=b5_r5_not}
N 7600 -270 7610 -270 {lab=x3_s6}
N 7600 -250 7610 -250 {lab=x3_s6_not}
N 7600 -150 7610 -150 {lab=b5_r6}
N 7600 -130 7610 -130 {lab=b5_r6_not}
N 7600 -190 7610 -190 {lab=x3_s7}
N 7600 -170 7610 -170 {lab=x3_s7_not}
N 7600 -70 7610 -70 {lab=b5_r7}
N 7600 -50 7610 -50 {lab=b5_r7_not}
N 7600 -110 7610 -110 {lab=x3_s8}
N 7600 -90 7610 -90 {lab=x3_s8_not}
N 8212.5 40 8322.5 40 {lab=x4_b0_f_not}
N 8072.5 100 8322.5 100 {lab=x4_s8}
N 8072.5 70 8122.5 70 {lab=vss}
N 8272.5 70 8322.5 70 {lab=vdd}
N 8072.5 160 8322.5 160 {lab=x4_s8}
N 8072.5 220 8322.5 220 {lab=x4_b0_f}
N 8072.5 190 8122.5 190 {lab=vss}
N 8272.5 190 8322.5 190 {lab=vdd}
N 8072.5 110 8072.5 160 {lab=x4_s8}
N 8032.5 70 8032.5 130 {lab=#net9}
N 8192.5 130 8362.5 130 {lab=#net9}
N 8362.5 130 8362.5 190 {lab=#net9}
N 8072.5 280 8322.5 280 {lab=x4_b0_f}
N 8072.5 340 8322.5 340 {lab=x4_s8_not}
N 8072.5 310 8122.5 310 {lab=vss}
N 8272.5 310 8322.5 310 {lab=vdd}
N 8072.5 400 8322.5 400 {lab=x4_s8_not}
N 8212.5 460 8322.5 460 {lab=x4_b0_f_not}
N 8072.5 430 8122.5 430 {lab=vss}
N 8272.5 430 8322.5 430 {lab=vdd}
N 8072.5 350 8072.5 400 {lab=x4_s8_not}
N 8032.5 310 8032.5 370 {lab=#net9}
N 8192.5 370 8362.5 370 {lab=#net9}
N 8362.5 370 8362.5 430 {lab=#net9}
N 8072.5 250 8072.5 280 {lab=x4_b0_f}
N 8012.5 190 8032.5 190 {lab=#net10}
N 7982.5 490 8212.5 490 {lab=x4_b0_f_not}
N 8192.5 -20 8192.5 130 {lab=#net9}
N 8192.5 130 8192.5 370 {lab=#net9}
N 7982.5 190 8012.5 190 {lab=#net10}
N 8362.5 70 8382.5 70 {lab=#net10}
N 8382.5 10 8382.5 70 {lab=#net10}
N 8362.5 310 8382.5 310 {lab=#net10}
N 8382.5 70 8382.5 310 {lab=#net10}
N 8072.5 110 8422.5 110 {lab=x4_s8}
N 7982.5 250 8072.5 250 {lab=x4_b0_f}
N 8012.5 430 8032.5 430 {lab=#net10}
N 8012.5 10 8382.5 10 {lab=#net10}
N 8012.5 10 8012.5 190 {lab=#net10}
N 8012.5 190 8012.5 430 {lab=#net10}
N 8212.5 40 8212.5 460 {lab=x4_b0_f_not}
N 8212.5 460 8212.5 490 {lab=x4_b0_f_not}
N 8072.5 350 8422.5 350 {lab=x4_s8_not}
N 8192.5 -20 8222.5 -20 {lab=#net9}
N 8382.5 10 8432.5 10 {lab=#net10}
N 7910 -20 7917.5 -20 {lab=#net9}
N 7910 20 7917.5 20 {lab=#net9}
N 7917.5 -20 7917.5 20 {lab=#net9}
N 7910 0 7925 0 {lab=#net10}
N 7910 40 7925 40 {lab=#net10}
N 7925 0 7925 40 {lab=#net10}
N 7917.5 -20 8192.5 -20 {lab=#net9}
N 7982.5 20 7982.5 190 {lab=#net10}
N 7910 -670 7920 -670 {lab=p5}
N 7910 -650 7920 -650 {lab=p5_not}
N 7910 -710 7920 -710 {lab=x4_c0_b}
N 7910 -690 7920 -690 {lab=x4_c0_b_not}
N 7910 -630 7920 -630 {lab=b5_r0_b}
N 7910 -610 7920 -610 {lab=b5_r0_b_not}
N 7910 -550 7920 -550 {lab=b5_r1_b}
N 7910 -530 7920 -530 {lab=b5_r1_b_not}
N 7910 -590 7920 -590 {lab=x4_s1}
N 7910 -570 7920 -570 {lab=x4_s1_not}
N 7910 -510 7920 -510 {lab=x4_s2}
N 7910 -490 7920 -490 {lab=x4_s2_not}
N 7910 -470 7920 -470 {lab=b5_r2_b}
N 7910 -450 7920 -450 {lab=b5_r2_b_not}
N 7910 -390 7920 -390 {lab=b5_r3_b}
N 7910 -370 7920 -370 {lab=b5_r3_b_not}
N 7910 -310 7920 -310 {lab=b5_r4_b}
N 7910 -290 7920 -290 {lab=b5_r4_b_not}
N 7910 -230 7920 -230 {lab=b5_r5_b}
N 7910 -210 7920 -210 {lab=b5_r5_b_not}
N 7910 -150 7920 -150 {lab=b5_r6_b}
N 7910 -130 7920 -130 {lab=b5_r6_b_not}
N 7910 -70 7920 -70 {lab=b5_r7_b}
N 7910 -50 7920 -50 {lab=b5_r7_b_not}
N 7910 -430 7920 -430 {lab=x4_s3}
N 7910 -410 7920 -410 {lab=x4_s3_not}
N 7910 -350 7920 -350 {lab=x4_s4}
N 7910 -330 7920 -330 {lab=x4_s4_not}
N 7910 -270 7920 -270 {lab=x4_s5}
N 7910 -250 7920 -250 {lab=x4_s5_not}
N 7910 -190 7920 -190 {lab=x4_s6}
N 7910 -170 7920 -170 {lab=x4_s6_not}
N 7910 -110 7920 -110 {lab=x4_s7}
N 7910 -90 7920 -90 {lab=x4_s7_not}
N 9017.5 -770 9017.5 -760 {lab=vdd}
N 8857.5 -570 8867.5 -570 {lab=b6_c0}
N 8857.5 -550 8867.5 -550 {lab=b6_c0_not}
N 8857.5 -650 8867.5 -650 {lab=a0}
N 8857.5 -630 8867.5 -630 {lab=a0_not}
N 8857.5 -610 8867.5 -610 {lab=b6}
N 8857.5 -590 8867.5 -590 {lab=b6_not}
N 9167.5 -570 9177.5 -570 {lab=b6_r0}
N 9167.5 -550 9177.5 -550 {lab=b6_r0_not}
N 9007.5 -440 9017.5 -440 {lab=vss}
N 9017.5 -405 9017.5 -395 {lab=vdd}
N 8857.5 -205 8867.5 -205 {lab=b6_c1}
N 8857.5 -185 8867.5 -185 {lab=b6_c1_not}
N 8857.5 -285 8867.5 -285 {lab=a1}
N 8857.5 -265 8867.5 -265 {lab=a1_not}
N 8857.5 -245 8867.5 -245 {lab=b6}
N 8857.5 -225 8867.5 -225 {lab=b6_not}
N 9167.5 -205 9177.5 -205 {lab=b6_r1}
N 9167.5 -185 9177.5 -185 {lab=b6_r1_not}
N 9007.5 -75 9017.5 -75 {lab=vss}
N 9017.5 -40 9017.5 -30 {lab=vdd}
N 8857.5 160 8867.5 160 {lab=b6_c2}
N 8857.5 180 8867.5 180 {lab=b6_c2_not}
N 8857.5 80 8867.5 80 {lab=a2}
N 8857.5 100 8867.5 100 {lab=a2_not}
N 8857.5 120 8867.5 120 {lab=b6}
N 8857.5 140 8867.5 140 {lab=b6_not}
N 9167.5 160 9177.5 160 {lab=b6_r2}
N 9167.5 180 9177.5 180 {lab=b6_r2_not}
N 9007.5 290 9017.5 290 {lab=vss}
N 9017.5 325 9017.5 335 {lab=vdd}
N 8857.5 525 8867.5 525 {lab=b6_c3}
N 8857.5 545 8867.5 545 {lab=b6_c3_not}
N 8857.5 445 8867.5 445 {lab=a3}
N 8857.5 465 8867.5 465 {lab=a3_not}
N 8857.5 485 8867.5 485 {lab=b6}
N 8857.5 505 8867.5 505 {lab=b6_not}
N 9167.5 525 9177.5 525 {lab=b6_r3}
N 9167.5 545 9177.5 545 {lab=b6_r3_not}
N 9007.5 655 9017.5 655 {lab=vss}
N 9017.5 702.5 9017.5 712.5 {lab=vdd}
N 8857.5 902.5 8867.5 902.5 {lab=b6_c4}
N 8857.5 922.5 8867.5 922.5 {lab=b6_c4_not}
N 8857.5 822.5 8867.5 822.5 {lab=a4}
N 8857.5 842.5 8867.5 842.5 {lab=a4_not}
N 8857.5 862.5 8867.5 862.5 {lab=b6}
N 8857.5 882.5 8867.5 882.5 {lab=b6_not}
N 9167.5 902.5 9177.5 902.5 {lab=b6_r4}
N 9167.5 922.5 9177.5 922.5 {lab=b6_r4_not}
N 9007.5 1032.5 9017.5 1032.5 {lab=vss}
N 9017.5 1067.5 9017.5 1077.5 {lab=vdd}
N 8857.5 1267.5 8867.5 1267.5 {lab=b6_c5}
N 8857.5 1287.5 8867.5 1287.5 {lab=b6_c5_not}
N 8857.5 1187.5 8867.5 1187.5 {lab=a5}
N 8857.5 1207.5 8867.5 1207.5 {lab=a5_not}
N 8857.5 1227.5 8867.5 1227.5 {lab=b6}
N 8857.5 1247.5 8867.5 1247.5 {lab=b6_not}
N 9167.5 1267.5 9177.5 1267.5 {lab=b6_r5}
N 9167.5 1287.5 9177.5 1287.5 {lab=b6_r5_not}
N 9007.5 1397.5 9017.5 1397.5 {lab=vss}
N 9017.5 1432.5 9017.5 1442.5 {lab=vdd}
N 8857.5 1632.5 8867.5 1632.5 {lab=b6_c6}
N 8857.5 1652.5 8867.5 1652.5 {lab=b6_c6_not}
N 8857.5 1552.5 8867.5 1552.5 {lab=a6}
N 8857.5 1572.5 8867.5 1572.5 {lab=a6_not}
N 8857.5 1592.5 8867.5 1592.5 {lab=b6}
N 8857.5 1612.5 8867.5 1612.5 {lab=b6_not}
N 9167.5 1632.5 9177.5 1632.5 {lab=b6_r6}
N 9167.5 1652.5 9177.5 1652.5 {lab=b6_r6_not}
N 9007.5 1762.5 9017.5 1762.5 {lab=vss}
N 9017.5 1797.5 9017.5 1807.5 {lab=vdd}
N 8857.5 1997.5 8867.5 1997.5 {lab=b6_c7}
N 8857.5 2017.5 8867.5 2017.5 {lab=b6_c7_not}
N 8857.5 1917.5 8867.5 1917.5 {lab=a7}
N 8857.5 1937.5 8867.5 1937.5 {lab=a7_not}
N 8857.5 1957.5 8867.5 1957.5 {lab=b6}
N 8857.5 1977.5 8867.5 1977.5 {lab=b6_not}
N 9167.5 1997.5 9177.5 1997.5 {lab=b6_r7}
N 9167.5 2017.5 9177.5 2017.5 {lab=b6_r7_not}
N 9007.5 2127.5 9017.5 2127.5 {lab=vss}
N 9167.5 -610 9177.5 -610 {lab=b6_q0}
N 9167.5 -590 9177.5 -590 {lab=b6_q0_not}
N 9167.5 -650 9177.5 -650 {lab=b6_p0}
N 9167.5 -630 9177.5 -630 {lab=b6_p0_not}
N 9167.5 -245 9177.5 -245 {lab=b6_q1}
N 9167.5 -225 9177.5 -225 {lab=b6_q1_not}
N 9167.5 -285 9177.5 -285 {lab=b6_p1}
N 9167.5 -265 9177.5 -265 {lab=b6_p1_not}
N 9167.5 120 9177.5 120 {lab=b6_q2}
N 9167.5 140 9177.5 140 {lab=b6_q2_not}
N 9167.5 80 9177.5 80 {lab=b6_p2}
N 9167.5 100 9177.5 100 {lab=b6_p2_not}
N 9167.5 485 9177.5 485 {lab=b6_q3}
N 9167.5 505 9177.5 505 {lab=b6_q3_not}
N 9167.5 445 9177.5 445 {lab=b6_p3}
N 9167.5 465 9177.5 465 {lab=b6_p3_not}
N 9167.5 862.5 9177.5 862.5 {lab=b6_q4}
N 9167.5 882.5 9177.5 882.5 {lab=b6_q4_not}
N 9167.5 822.5 9177.5 822.5 {lab=b6_p4}
N 9167.5 842.5 9177.5 842.5 {lab=b6_p4_not}
N 9167.5 1227.5 9177.5 1227.5 {lab=b6_q5}
N 9167.5 1247.5 9177.5 1247.5 {lab=b6_q5_not}
N 9167.5 1187.5 9177.5 1187.5 {lab=b6_p5}
N 9167.5 1207.5 9177.5 1207.5 {lab=b6_p5_not}
N 9167.5 1592.5 9177.5 1592.5 {lab=b6_q6}
N 9167.5 1612.5 9177.5 1612.5 {lab=b6_q6_not}
N 9167.5 1552.5 9177.5 1552.5 {lab=b6_p6}
N 9167.5 1572.5 9177.5 1572.5 {lab=b6_p6_not}
N 9167.5 1957.5 9177.5 1957.5 {lab=b6_q7}
N 9167.5 1977.5 9177.5 1977.5 {lab=b6_q7_not}
N 9167.5 1917.5 9177.5 1917.5 {lab=b6_p7}
N 9167.5 1937.5 9177.5 1937.5 {lab=b6_p7_not}
N 9862.5 -760 9862.5 -740 {lab=vdd}
N 9862.5 70 9862.5 90 {lab=vss}
N 9702.5 -630 9712.5 -630 {lab=b6_r0}
N 9702.5 -610 9712.5 -610 {lab=b6_r0_not}
N 9702.5 -670 9712.5 -670 {lab=x4_s1}
N 9702.5 -650 9712.5 -650 {lab=x4_s1_not}
N 9692.5 -690 9712.5 -690 {lab=x5_c0_f_not}
N 9692.5 -710 9712.5 -710 {lab=x5_c0_f}
N 9702.5 -550 9712.5 -550 {lab=b6_r1}
N 9702.5 -530 9712.5 -530 {lab=b6_r1_not}
N 9702.5 -590 9712.5 -590 {lab=x4_s2}
N 9702.5 -570 9712.5 -570 {lab=x4_s2_not}
N 9702.5 -470 9712.5 -470 {lab=b6_r2}
N 9702.5 -450 9712.5 -450 {lab=b6_r2_not}
N 9702.5 -510 9712.5 -510 {lab=x4_s3}
N 9702.5 -490 9712.5 -490 {lab=x4_s3_not}
N 9702.5 -390 9712.5 -390 {lab=b6_r3}
N 9702.5 -370 9712.5 -370 {lab=b6_r3_not}
N 9702.5 -430 9712.5 -430 {lab=x4_s4}
N 9702.5 -410 9712.5 -410 {lab=x4_s4_not}
N 9702.5 -310 9712.5 -310 {lab=b6_r4}
N 9702.5 -290 9712.5 -290 {lab=b6_r4_not}
N 9702.5 -350 9712.5 -350 {lab=x4_s5}
N 9702.5 -330 9712.5 -330 {lab=x4_s5_not}
N 9702.5 -230 9712.5 -230 {lab=b6_r5}
N 9702.5 -210 9712.5 -210 {lab=b6_r5_not}
N 9702.5 -270 9712.5 -270 {lab=x4_s6}
N 9702.5 -250 9712.5 -250 {lab=x4_s6_not}
N 9702.5 -150 9712.5 -150 {lab=b6_r6}
N 9702.5 -130 9712.5 -130 {lab=b6_r6_not}
N 9702.5 -190 9712.5 -190 {lab=x4_s7}
N 9702.5 -170 9712.5 -170 {lab=x4_s7_not}
N 9702.5 -70 9712.5 -70 {lab=b6_r7}
N 9702.5 -50 9712.5 -50 {lab=b6_r7_not}
N 9702.5 -110 9712.5 -110 {lab=x4_s8}
N 9702.5 -90 9712.5 -90 {lab=x4_s8_not}
N 10315 40 10425 40 {lab=x5_b0_f_not}
N 10175 100 10425 100 {lab=x5_s8}
N 10175 70 10225 70 {lab=vss}
N 10375 70 10425 70 {lab=vdd}
N 10175 160 10425 160 {lab=x5_s8}
N 10175 220 10425 220 {lab=x5_b0_f}
N 10175 190 10225 190 {lab=vss}
N 10375 190 10425 190 {lab=vdd}
N 10175 110 10175 160 {lab=x5_s8}
N 10135 70 10135 130 {lab=#net11}
N 10295 130 10465 130 {lab=#net11}
N 10465 130 10465 190 {lab=#net11}
N 10175 280 10425 280 {lab=x5_b0_f}
N 10175 340 10425 340 {lab=x5_s8_not}
N 10175 310 10225 310 {lab=vss}
N 10375 310 10425 310 {lab=vdd}
N 10175 400 10425 400 {lab=x5_s8_not}
N 10315 460 10425 460 {lab=x5_b0_f_not}
N 10175 430 10225 430 {lab=vss}
N 10375 430 10425 430 {lab=vdd}
N 10175 350 10175 400 {lab=x5_s8_not}
N 10135 310 10135 370 {lab=#net11}
N 10295 370 10465 370 {lab=#net11}
N 10465 370 10465 430 {lab=#net11}
N 10175 250 10175 280 {lab=x5_b0_f}
N 10115 190 10135 190 {lab=#net12}
N 10085 490 10315 490 {lab=x5_b0_f_not}
N 10295 -20 10295 130 {lab=#net11}
N 10295 130 10295 370 {lab=#net11}
N 10085 190 10115 190 {lab=#net12}
N 10465 70 10485 70 {lab=#net12}
N 10485 10 10485 70 {lab=#net12}
N 10465 310 10485 310 {lab=#net12}
N 10485 70 10485 310 {lab=#net12}
N 10175 110 10525 110 {lab=x5_s8}
N 10085 250 10175 250 {lab=x5_b0_f}
N 10115 430 10135 430 {lab=#net12}
N 10115 10 10485 10 {lab=#net12}
N 10115 10 10115 190 {lab=#net12}
N 10115 190 10115 430 {lab=#net12}
N 10315 40 10315 460 {lab=x5_b0_f_not}
N 10315 460 10315 490 {lab=x5_b0_f_not}
N 10175 350 10525 350 {lab=x5_s8_not}
N 10295 -20 10325 -20 {lab=#net11}
N 10485 10 10535 10 {lab=#net12}
N 10012.5 -20 10020 -20 {lab=#net11}
N 10012.5 20 10020 20 {lab=#net11}
N 10020 -20 10020 20 {lab=#net11}
N 10012.5 0 10027.5 0 {lab=#net12}
N 10012.5 40 10027.5 40 {lab=#net12}
N 10027.5 0 10027.5 40 {lab=#net12}
N 10020 -20 10295 -20 {lab=#net11}
N 10085 20 10085 190 {lab=#net12}
N 10012.5 -670 10022.5 -670 {lab=p6}
N 10012.5 -650 10022.5 -650 {lab=p6_not}
N 10012.5 -710 10022.5 -710 {lab=x5_c0_b}
N 10012.5 -690 10022.5 -690 {lab=x5_c0_b_not}
N 10012.5 -630 10022.5 -630 {lab=b6_r0_b}
N 10012.5 -610 10022.5 -610 {lab=b6_r0_b_not}
N 10012.5 -550 10022.5 -550 {lab=b6_r1_b}
N 10012.5 -530 10022.5 -530 {lab=b6_r1_b_not}
N 10012.5 -590 10022.5 -590 {lab=x5_s1}
N 10012.5 -570 10022.5 -570 {lab=x5_s1_not}
N 10012.5 -510 10022.5 -510 {lab=x5_s2}
N 10012.5 -490 10022.5 -490 {lab=x5_s2_not}
N 10012.5 -470 10022.5 -470 {lab=b6_r2_b}
N 10012.5 -450 10022.5 -450 {lab=b6_r2_b_not}
N 10012.5 -390 10022.5 -390 {lab=b6_r3_b}
N 10012.5 -370 10022.5 -370 {lab=b6_r3_b_not}
N 10012.5 -310 10022.5 -310 {lab=b6_r4_b}
N 10012.5 -290 10022.5 -290 {lab=b6_r4_b_not}
N 10012.5 -230 10022.5 -230 {lab=b6_r5_b}
N 10012.5 -210 10022.5 -210 {lab=b6_r5_b_not}
N 10012.5 -150 10022.5 -150 {lab=b6_r6_b}
N 10012.5 -130 10022.5 -130 {lab=b6_r6_b_not}
N 10012.5 -70 10022.5 -70 {lab=b6_r7_b}
N 10012.5 -50 10022.5 -50 {lab=b6_r7_b_not}
N 10012.5 -430 10022.5 -430 {lab=x5_s3}
N 10012.5 -410 10022.5 -410 {lab=x5_s3_not}
N 10012.5 -350 10022.5 -350 {lab=x5_s4}
N 10012.5 -330 10022.5 -330 {lab=x5_s4_not}
N 10012.5 -270 10022.5 -270 {lab=x5_s5}
N 10012.5 -250 10022.5 -250 {lab=x5_s5_not}
N 10012.5 -190 10022.5 -190 {lab=x5_s6}
N 10012.5 -170 10022.5 -170 {lab=x5_s6_not}
N 10012.5 -110 10022.5 -110 {lab=x5_s7}
N 10012.5 -90 10022.5 -90 {lab=x5_s7_not}
N 11195 -735 11195 -725 {lab=vdd}
N 11035 -535 11045 -535 {lab=b7_c0}
N 11035 -515 11045 -515 {lab=b7_c0_not}
N 11035 -615 11045 -615 {lab=a0}
N 11035 -595 11045 -595 {lab=a0_not}
N 11035 -575 11045 -575 {lab=b7}
N 11035 -555 11045 -555 {lab=b7_not}
N 11345 -535 11355 -535 {lab=b7_r0}
N 11345 -515 11355 -515 {lab=b7_r0_not}
N 11185 -405 11195 -405 {lab=vss}
N 11195 -370 11195 -360 {lab=vdd}
N 11035 -170 11045 -170 {lab=b7_c1}
N 11035 -150 11045 -150 {lab=b7_c1_not}
N 11035 -250 11045 -250 {lab=a1}
N 11035 -230 11045 -230 {lab=a1_not}
N 11035 -210 11045 -210 {lab=b7}
N 11035 -190 11045 -190 {lab=b7_not}
N 11345 -170 11355 -170 {lab=b7_r1}
N 11345 -150 11355 -150 {lab=b7_r1_not}
N 11185 -40 11195 -40 {lab=vss}
N 11195 -5 11195 5 {lab=vdd}
N 11035 195 11045 195 {lab=b7_c2}
N 11035 215 11045 215 {lab=b7_c2_not}
N 11035 115 11045 115 {lab=a2}
N 11035 135 11045 135 {lab=a2_not}
N 11035 155 11045 155 {lab=b7}
N 11035 175 11045 175 {lab=b7_not}
N 11345 195 11355 195 {lab=b7_r2}
N 11345 215 11355 215 {lab=b7_r2_not}
N 11185 325 11195 325 {lab=vss}
N 11195 360 11195 370 {lab=vdd}
N 11035 560 11045 560 {lab=b7_c3}
N 11035 580 11045 580 {lab=b7_c3_not}
N 11035 480 11045 480 {lab=a3}
N 11035 500 11045 500 {lab=a3_not}
N 11035 520 11045 520 {lab=b7}
N 11035 540 11045 540 {lab=b7_not}
N 11345 560 11355 560 {lab=b7_r3}
N 11345 580 11355 580 {lab=b7_r3_not}
N 11185 690 11195 690 {lab=vss}
N 11195 737.5 11195 747.5 {lab=vdd}
N 11035 937.5 11045 937.5 {lab=b7_c4}
N 11035 957.5 11045 957.5 {lab=b7_c4_not}
N 11035 857.5 11045 857.5 {lab=a4}
N 11035 877.5 11045 877.5 {lab=a4_not}
N 11035 897.5 11045 897.5 {lab=b7}
N 11035 917.5 11045 917.5 {lab=b7_not}
N 11345 937.5 11355 937.5 {lab=b7_r4}
N 11345 957.5 11355 957.5 {lab=b7_r4_not}
N 11185 1067.5 11195 1067.5 {lab=vss}
N 11195 1102.5 11195 1112.5 {lab=vdd}
N 11035 1302.5 11045 1302.5 {lab=b7_c5}
N 11035 1322.5 11045 1322.5 {lab=b7_c5_not}
N 11035 1222.5 11045 1222.5 {lab=a5}
N 11035 1242.5 11045 1242.5 {lab=a5_not}
N 11035 1262.5 11045 1262.5 {lab=b7}
N 11035 1282.5 11045 1282.5 {lab=b7_not}
N 11345 1302.5 11355 1302.5 {lab=b7_r5}
N 11345 1322.5 11355 1322.5 {lab=b7_r5_not}
N 11185 1432.5 11195 1432.5 {lab=vss}
N 11195 1467.5 11195 1477.5 {lab=vdd}
N 11035 1667.5 11045 1667.5 {lab=b7_c6}
N 11035 1687.5 11045 1687.5 {lab=b7_c6_not}
N 11035 1587.5 11045 1587.5 {lab=a6}
N 11035 1607.5 11045 1607.5 {lab=a6_not}
N 11035 1627.5 11045 1627.5 {lab=b7}
N 11035 1647.5 11045 1647.5 {lab=b7_not}
N 11345 1667.5 11355 1667.5 {lab=b7_r6}
N 11345 1687.5 11355 1687.5 {lab=b7_r6_not}
N 11185 1797.5 11195 1797.5 {lab=vss}
N 11195 1832.5 11195 1842.5 {lab=vdd}
N 11035 2032.5 11045 2032.5 {lab=b7_c7}
N 11035 2052.5 11045 2052.5 {lab=b7_c7_not}
N 11035 1952.5 11045 1952.5 {lab=a7}
N 11035 1972.5 11045 1972.5 {lab=a7_not}
N 11035 1992.5 11045 1992.5 {lab=b7}
N 11035 2012.5 11045 2012.5 {lab=b7_not}
N 11345 2032.5 11355 2032.5 {lab=b7_r7}
N 11345 2052.5 11355 2052.5 {lab=b7_r7_not}
N 11185 2162.5 11195 2162.5 {lab=vss}
N 11345 -575 11355 -575 {lab=b7_q0}
N 11345 -555 11355 -555 {lab=b7_q0_not}
N 11345 -615 11355 -615 {lab=b7_p0}
N 11345 -595 11355 -595 {lab=b7_p0_not}
N 11345 -210 11355 -210 {lab=b7_q1}
N 11345 -190 11355 -190 {lab=b7_q1_not}
N 11345 -250 11355 -250 {lab=b7_p1}
N 11345 -230 11355 -230 {lab=b7_p1_not}
N 11345 155 11355 155 {lab=b7_q2}
N 11345 175 11355 175 {lab=b7_q2_not}
N 11345 115 11355 115 {lab=b7_p2}
N 11345 135 11355 135 {lab=b7_p2_not}
N 11345 520 11355 520 {lab=b7_q3}
N 11345 540 11355 540 {lab=b7_q3_not}
N 11345 480 11355 480 {lab=b7_p3}
N 11345 500 11355 500 {lab=b7_p3_not}
N 11345 897.5 11355 897.5 {lab=b7_q4}
N 11345 917.5 11355 917.5 {lab=b7_q4_not}
N 11345 857.5 11355 857.5 {lab=b7_p4}
N 11345 877.5 11355 877.5 {lab=b7_p4_not}
N 11345 1262.5 11355 1262.5 {lab=b7_q5}
N 11345 1282.5 11355 1282.5 {lab=b7_q5_not}
N 11345 1222.5 11355 1222.5 {lab=b7_p5}
N 11345 1242.5 11355 1242.5 {lab=b7_p5_not}
N 11345 1627.5 11355 1627.5 {lab=b7_q6}
N 11345 1647.5 11355 1647.5 {lab=b7_q6_not}
N 11345 1587.5 11355 1587.5 {lab=b7_p6}
N 11345 1607.5 11355 1607.5 {lab=b7_p6_not}
N 11345 1992.5 11355 1992.5 {lab=b7_q7}
N 11345 2012.5 11355 2012.5 {lab=b7_q7_not}
N 11345 1952.5 11355 1952.5 {lab=b7_p7}
N 11345 1972.5 11355 1972.5 {lab=b7_p7_not}
N 12180 -732.5 12180 -712.5 {lab=vdd}
N 12180 97.5 12180 117.5 {lab=vss}
N 12020 -602.5 12030 -602.5 {lab=b7_r0}
N 12020 -582.5 12030 -582.5 {lab=b7_r0_not}
N 12020 -642.5 12030 -642.5 {lab=x5_s1}
N 12020 -622.5 12030 -622.5 {lab=x5_s1_not}
N 12010 -662.5 12030 -662.5 {lab=x6_c0_f_not}
N 12010 -682.5 12030 -682.5 {lab=x6_c0_f}
N 12020 -522.5 12030 -522.5 {lab=b7_r1}
N 12020 -502.5 12030 -502.5 {lab=b7_r1_not}
N 12020 -562.5 12030 -562.5 {lab=x5_s2}
N 12020 -542.5 12030 -542.5 {lab=x5_s2_not}
N 12020 -442.5 12030 -442.5 {lab=b7_r2}
N 12020 -422.5 12030 -422.5 {lab=b7_r2_not}
N 12020 -482.5 12030 -482.5 {lab=x5_s3}
N 12020 -462.5 12030 -462.5 {lab=x5_s3_not}
N 12020 -362.5 12030 -362.5 {lab=b7_r3}
N 12020 -342.5 12030 -342.5 {lab=b7_r3_not}
N 12020 -402.5 12030 -402.5 {lab=x5_s4}
N 12020 -382.5 12030 -382.5 {lab=x5_s4_not}
N 12020 -282.5 12030 -282.5 {lab=b7_r4}
N 12020 -262.5 12030 -262.5 {lab=b7_r4_not}
N 12020 -322.5 12030 -322.5 {lab=x5_s5}
N 12020 -302.5 12030 -302.5 {lab=x5_s5_not}
N 12020 -202.5 12030 -202.5 {lab=b7_r5}
N 12020 -182.5 12030 -182.5 {lab=b7_r5_not}
N 12020 -242.5 12030 -242.5 {lab=x5_s6}
N 12020 -222.5 12030 -222.5 {lab=x5_s6_not}
N 12020 -122.5 12030 -122.5 {lab=b7_r6}
N 12020 -102.5 12030 -102.5 {lab=b7_r6_not}
N 12020 -162.5 12030 -162.5 {lab=x5_s7}
N 12020 -142.5 12030 -142.5 {lab=x5_s7_not}
N 12020 -42.5 12030 -42.5 {lab=b7_r7}
N 12020 -22.5 12030 -22.5 {lab=b7_r7_not}
N 12020 -82.5 12030 -82.5 {lab=x5_s8}
N 12020 -62.5 12030 -62.5 {lab=x5_s8_not}
N 12632.5 67.5 12742.5 67.5 {lab=x6_b0_f_not}
N 12492.5 127.5 12742.5 127.5 {lab=p15}
N 12492.5 97.5 12542.5 97.5 {lab=vss}
N 12692.5 97.5 12742.5 97.5 {lab=vdd}
N 12492.5 187.5 12742.5 187.5 {lab=p15}
N 12492.5 247.5 12742.5 247.5 {lab=x6_b0_f}
N 12492.5 217.5 12542.5 217.5 {lab=vss}
N 12692.5 217.5 12742.5 217.5 {lab=vdd}
N 12492.5 137.5 12492.5 187.5 {lab=p15}
N 12452.5 97.5 12452.5 157.5 {lab=#net13}
N 12612.5 157.5 12782.5 157.5 {lab=#net13}
N 12782.5 157.5 12782.5 217.5 {lab=#net13}
N 12492.5 307.5 12742.5 307.5 {lab=x6_b0_f}
N 12492.5 367.5 12742.5 367.5 {lab=p15_not}
N 12492.5 337.5 12542.5 337.5 {lab=vss}
N 12692.5 337.5 12742.5 337.5 {lab=vdd}
N 12492.5 427.5 12742.5 427.5 {lab=p15_not}
N 12632.5 487.5 12742.5 487.5 {lab=x6_b0_f_not}
N 12492.5 457.5 12542.5 457.5 {lab=vss}
N 12692.5 457.5 12742.5 457.5 {lab=vdd}
N 12492.5 377.5 12492.5 427.5 {lab=p15_not}
N 12452.5 337.5 12452.5 397.5 {lab=#net13}
N 12612.5 397.5 12782.5 397.5 {lab=#net13}
N 12782.5 397.5 12782.5 457.5 {lab=#net13}
N 12492.5 277.5 12492.5 307.5 {lab=x6_b0_f}
N 12432.5 217.5 12452.5 217.5 {lab=#net14}
N 12402.5 517.5 12632.5 517.5 {lab=x6_b0_f_not}
N 12612.5 7.5 12612.5 157.5 {lab=#net13}
N 12612.5 157.5 12612.5 397.5 {lab=#net13}
N 12402.5 217.5 12432.5 217.5 {lab=#net14}
N 12782.5 97.5 12802.5 97.5 {lab=#net14}
N 12802.5 37.5 12802.5 97.5 {lab=#net14}
N 12782.5 337.5 12802.5 337.5 {lab=#net14}
N 12802.5 97.5 12802.5 337.5 {lab=#net14}
N 12492.5 137.5 12842.5 137.5 {lab=p15}
N 12402.5 277.5 12492.5 277.5 {lab=x6_b0_f}
N 12432.5 457.5 12452.5 457.5 {lab=#net14}
N 12432.5 37.5 12802.5 37.5 {lab=#net14}
N 12432.5 37.5 12432.5 217.5 {lab=#net14}
N 12432.5 217.5 12432.5 457.5 {lab=#net14}
N 12632.5 67.5 12632.5 487.5 {lab=x6_b0_f_not}
N 12632.5 487.5 12632.5 517.5 {lab=x6_b0_f_not}
N 12492.5 377.5 12842.5 377.5 {lab=p15_not}
N 12612.5 7.5 12642.5 7.5 {lab=#net13}
N 12802.5 37.5 12852.5 37.5 {lab=#net14}
N 12330 7.5 12337.5 7.5 {lab=#net13}
N 12330 47.5 12337.5 47.5 {lab=#net13}
N 12337.5 7.5 12337.5 47.5 {lab=#net13}
N 12330 27.5 12345 27.5 {lab=#net14}
N 12330 67.5 12345 67.5 {lab=#net14}
N 12345 27.5 12345 67.5 {lab=#net14}
N 12337.5 7.5 12612.5 7.5 {lab=#net13}
N 12402.5 47.5 12402.5 217.5 {lab=#net14}
N 12330 -642.5 12340 -642.5 {lab=p7}
N 12330 -622.5 12340 -622.5 {lab=p7_not}
N 12330 -682.5 12340 -682.5 {lab=x6_c0_b}
N 12330 -662.5 12340 -662.5 {lab=x6_c0_b_not}
N 12330 -602.5 12340 -602.5 {lab=b7_r0_b}
N 12330 -582.5 12340 -582.5 {lab=b7_r0_b_not}
N 12330 -522.5 12340 -522.5 {lab=b7_r1_b}
N 12330 -502.5 12340 -502.5 {lab=b7_r1_b_not}
N 12330 -562.5 12340 -562.5 {lab=p8}
N 12330 -542.5 12340 -542.5 {lab=p8_not}
N 12330 -442.5 12340 -442.5 {lab=b7_r2_b}
N 12330 -422.5 12340 -422.5 {lab=b7_r2_b_not}
N 12330 -362.5 12340 -362.5 {lab=b7_r3_b}
N 12330 -342.5 12340 -342.5 {lab=b7_r3_b_not}
N 12330 -282.5 12340 -282.5 {lab=b7_r4_b}
N 12330 -262.5 12340 -262.5 {lab=b7_r4_b_not}
N 12330 -202.5 12340 -202.5 {lab=b7_r5_b}
N 12330 -182.5 12340 -182.5 {lab=b7_r5_b_not}
N 12330 -122.5 12340 -122.5 {lab=b7_r6_b}
N 12330 -102.5 12340 -102.5 {lab=b7_r6_b_not}
N 12330 -42.5 12340 -42.5 {lab=b7_r7_b}
N 12330 -22.5 12340 -22.5 {lab=b7_r7_b_not}
N 12330 -402.5 12340 -402.5 {lab=p10}
N 12330 -382.5 12340 -382.5 {lab=p10_not}
N 12330 -322.5 12340 -322.5 {lab=p11}
N 12330 -302.5 12340 -302.5 {lab=p11_not}
N 12330 -242.5 12340 -242.5 {lab=p12}
N 12330 -222.5 12340 -222.5 {lab=p12_not}
N 12330 -162.5 12340 -162.5 {lab=p13}
N 12330 -142.5 12340 -142.5 {lab=p13_not}
N 12330 -82.5 12340 -82.5 {lab=p14}
N 12330 -62.5 12340 -62.5 {lab=p14_not}
N 12330 -482.5 12340 -482.5 {lab=p9}
N 12330 -462.5 12340 -462.5 {lab=p9_not}
N 402.5 150 562.5 150 {lab=#net1}
N 402.5 390 562.5 390 {lab=#net1}
N 442.5 120 442.5 130 {lab=x0_s8}
N 442.5 240 442.5 270 {lab=x0_b0_f}
N 442.5 60 582.5 60 {lab=x0_b0_f_not}
N 442.5 480 582.5 480 {lab=x0_b0_f_not}
N 442.5 360 442.5 370 {lab=x0_s8_not}
N 2342.5 170 2502.5 170 {lab=#net3}
N 2342.5 410 2502.5 410 {lab=#net3}
N 2382.5 140 2382.5 150 {lab=x1_s8}
N 2382.5 260 2382.5 290 {lab=x1_b0_f}
N 2382.5 80 2522.5 80 {lab=x1_b0_f_not}
N 2382.5 500 2522.5 500 {lab=x1_b0_f_not}
N 2382.5 380 2382.5 390 {lab=x1_s8_not}
N 4147.5 162.5 4307.5 162.5 {lab=#net5}
N 4147.5 402.5 4307.5 402.5 {lab=#net5}
N 4187.5 132.5 4187.5 142.5 {lab=x2_s8}
N 4187.5 252.5 4187.5 282.5 {lab=x2_b0_f}
N 4187.5 72.5 4327.5 72.5 {lab=x2_b0_f_not}
N 4187.5 492.5 4327.5 492.5 {lab=x2_b0_f_not}
N 4187.5 372.5 4187.5 382.5 {lab=x2_s8_not}
N 6005 132.5 6165 132.5 {lab=#net7}
N 6005 372.5 6165 372.5 {lab=#net7}
N 6045 102.5 6045 112.5 {lab=x3_s8}
N 6045 222.5 6045 252.5 {lab=x3_b0_f}
N 6045 42.5 6185 42.5 {lab=x3_b0_f_not}
N 6045 462.5 6185 462.5 {lab=x3_b0_f_not}
N 6045 342.5 6045 352.5 {lab=x3_s8_not}
N 8032.5 130 8192.5 130 {lab=#net9}
N 8032.5 370 8192.5 370 {lab=#net9}
N 8072.5 100 8072.5 110 {lab=x4_s8}
N 8072.5 220 8072.5 250 {lab=x4_b0_f}
N 8072.5 40 8212.5 40 {lab=x4_b0_f_not}
N 8072.5 460 8212.5 460 {lab=x4_b0_f_not}
N 8072.5 340 8072.5 350 {lab=x4_s8_not}
N 10135 130 10295 130 {lab=#net11}
N 10135 370 10295 370 {lab=#net11}
N 10175 100 10175 110 {lab=x5_s8}
N 10175 220 10175 250 {lab=x5_b0_f}
N 10175 40 10315 40 {lab=x5_b0_f_not}
N 10175 460 10315 460 {lab=x5_b0_f_not}
N 10175 340 10175 350 {lab=x5_s8_not}
N 12452.5 157.5 12612.5 157.5 {lab=#net13}
N 12452.5 397.5 12612.5 397.5 {lab=#net13}
N 12492.5 127.5 12492.5 137.5 {lab=p15}
N 12492.5 247.5 12492.5 277.5 {lab=x6_b0_f}
N 12492.5 67.5 12632.5 67.5 {lab=x6_b0_f_not}
N 12492.5 487.5 12632.5 487.5 {lab=x6_b0_f_not}
N 12492.5 367.5 12492.5 377.5 {lab=p15_not}
N -1760 -625 -1690 -625 {lab=b2}
N -1760 -605 -1690 -605 {lab=b2_not}
N -1760 -585 -1690 -585 {lab=b3}
N -1760 -565 -1690 -565 {lab=b3_not}
N -1760 -545 -1690 -545 {lab=b4}
N -1760 -525 -1690 -525 {lab=b4_not}
N -1760 -505 -1690 -505 {lab=b5}
N -1760 -485 -1690 -485 {lab=b5_not}
N -1760 -465 -1690 -465 {lab=b6}
N -1760 -445 -1690 -445 {lab=b6_not}
N -1760 -425 -1690 -425 {lab=b7}
N -1760 -405 -1690 -405 {lab=b7_not}
N 10027.5 20 10085 20 {lab=#net12}
N 7925 20 7982.5 20 {lab=#net10}
N 12345 47.5 12402.5 47.5 {lab=#net14}
N 5897.5 22.5 5955 22.5 {lab=#net8}
N 4040 52.5 4097.5 52.5 {lab=#net6}
N 2235 60 2292.5 60 {lab=#net4}
N 295 40 352.5 40 {lab=#net2}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 130 -960 0 0 {name=x2}
C {iopin.sym} -1760 -1085 2 0 {name=p1 lab=vss}
C {iopin.sym} -1760 -1105 2 0 {name=p2 lab=vdd}
C {lab_wire.sym} -1690 -1105 0 0 {name=p3 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1690 -1085 0 0 {name=p4 sig_type=std_logic lab=vss}
C {lab_wire.sym} 130 -720 0 0 {name=p5 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 130 90 0 0 {name=p6 sig_type=std_logic lab=vss}
C {iopin.sym} -1760 -1025 2 0 {name=p10 lab=a0_not}
C {iopin.sym} -1760 -1045 2 0 {name=p11 lab=a0}
C {iopin.sym} -1760 -985 2 0 {name=p12 lab=a1_not}
C {iopin.sym} -1760 -1005 2 0 {name=p13 lab=a1}
C {iopin.sym} -1760 -945 2 0 {name=p14 lab=a2_not}
C {iopin.sym} -1760 -965 2 0 {name=p15 lab=a2}
C {iopin.sym} -1760 -905 2 0 {name=p16 lab=a3_not}
C {iopin.sym} -1760 -925 2 0 {name=p17 lab=a3}
C {iopin.sym} -1760 -865 2 0 {name=p18 lab=a4_not}
C {iopin.sym} -1760 -885 2 0 {name=p19 lab=a4}
C {iopin.sym} -1760 -825 2 0 {name=p20 lab=a5_not}
C {iopin.sym} -1760 -845 2 0 {name=p21 lab=a5}
C {iopin.sym} -1760 -785 2 0 {name=p22 lab=a6_not}
C {iopin.sym} -1760 -805 2 0 {name=p23 lab=a6}
C {iopin.sym} -1760 -745 2 0 {name=p24 lab=a7_not}
C {iopin.sym} -1760 -765 2 0 {name=p25 lab=a7}
C {lab_wire.sym} -1690 -1045 0 0 {name=p26 sig_type=std_logic lab=a0}
C {lab_wire.sym} -1690 -1025 0 0 {name=p27 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} -1690 -1005 0 0 {name=p28 sig_type=std_logic lab=a1}
C {lab_wire.sym} -1690 -985 0 0 {name=p29 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} -1690 -965 0 0 {name=p30 sig_type=std_logic lab=a2}
C {lab_wire.sym} -1690 -945 0 0 {name=p31 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} -1690 -925 0 0 {name=p32 sig_type=std_logic lab=a3}
C {lab_wire.sym} -1690 -905 0 0 {name=p33 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} -1690 -885 0 0 {name=p34 sig_type=std_logic lab=a4}
C {lab_wire.sym} -1690 -865 0 0 {name=p35 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} -1690 -845 0 0 {name=p36 sig_type=std_logic lab=a5}
C {lab_wire.sym} -1690 -825 0 0 {name=p37 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} -1690 -805 0 0 {name=p38 sig_type=std_logic lab=a6}
C {lab_wire.sym} -1690 -785 0 0 {name=p39 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} -1690 -765 0 0 {name=p40 sig_type=std_logic lab=a7}
C {lab_wire.sym} -1690 -745 0 0 {name=p41 sig_type=std_logic lab=a7_not}
C {iopin.sym} -1760 -685 2 0 {name=p9 lab=b0_not}
C {iopin.sym} -1760 -705 2 0 {name=p42 lab=b0}
C {iopin.sym} -1760 -645 2 0 {name=p43 lab=b1_not}
C {iopin.sym} -1760 -665 2 0 {name=p44 lab=b1}
C {lab_wire.sym} -1690 -705 0 0 {name=p57 sig_type=std_logic lab=b0}
C {lab_wire.sym} -1690 -685 0 0 {name=p58 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -1690 -665 0 0 {name=p59 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1690 -645 0 0 {name=p60 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} 130 -1130 0 0 {name=p45 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 130 -790 0 0 {name=p46 sig_type=std_logic lab=vss}
C {lab_wire.sym} -30 -990 0 0 {name=p49 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} -30 -1010 0 0 {name=p50 sig_type=std_logic lab=a0}
C {lab_wire.sym} -30 -950 0 0 {name=p51 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -30 -970 0 0 {name=p52 sig_type=std_logic lab=b0}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -1180 -962.5 0 0 {name=x4}
C {lab_wire.sym} -1180 -1132.5 0 0 {name=p55 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1340 -992.5 0 0 {name=p62 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} -1340 -1012.5 0 0 {name=p63 sig_type=std_logic lab=a0}
C {lab_wire.sym} -1340 -952.5 0 0 {name=p64 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} -1340 -972.5 0 0 {name=p65 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1190 -802.5 0 0 {name=p66 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -1180 -597.5 0 0 {name=x5}
C {lab_wire.sym} -1180 -767.5 0 0 {name=p67 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1340 -627.5 0 0 {name=p70 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} -1340 -647.5 0 0 {name=p71 sig_type=std_logic lab=a1}
C {lab_wire.sym} -1340 -587.5 0 0 {name=p72 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} -1340 -607.5 0 0 {name=p73 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1190 -437.5 0 0 {name=p74 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -1180 -232.5 0 0 {name=x6}
C {lab_wire.sym} -1180 -402.5 0 0 {name=p75 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1340 -262.5 0 0 {name=p78 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} -1340 -282.5 0 0 {name=p79 sig_type=std_logic lab=a2}
C {lab_wire.sym} -1340 -222.5 0 0 {name=p80 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} -1340 -242.5 0 0 {name=p81 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1190 -72.5 0 0 {name=p82 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -1180 132.5 0 0 {name=x7}
C {lab_wire.sym} -1180 -37.5 0 0 {name=p83 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1340 102.5 0 0 {name=p86 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} -1340 82.5 0 0 {name=p87 sig_type=std_logic lab=a3}
C {lab_wire.sym} -1340 142.5 0 0 {name=p88 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} -1340 122.5 0 0 {name=p89 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1190 292.5 0 0 {name=p90 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -1180 510 0 0 {name=x8}
C {lab_wire.sym} -1180 340 0 0 {name=p91 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1340 480 0 0 {name=p94 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} -1340 460 0 0 {name=p95 sig_type=std_logic lab=a4}
C {lab_wire.sym} -1340 520 0 0 {name=p96 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} -1340 500 0 0 {name=p97 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1190 670 0 0 {name=p98 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -1180 875 0 0 {name=x9}
C {lab_wire.sym} -1180 705 0 0 {name=p99 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1340 845 0 0 {name=p102 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} -1340 825 0 0 {name=p103 sig_type=std_logic lab=a5}
C {lab_wire.sym} -1340 885 0 0 {name=p104 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} -1340 865 0 0 {name=p105 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1190 1035 0 0 {name=p106 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -1180 1240 0 0 {name=x10}
C {lab_wire.sym} -1180 1070 0 0 {name=p107 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1340 1210 0 0 {name=p110 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} -1340 1190 0 0 {name=p111 sig_type=std_logic lab=a6}
C {lab_wire.sym} -1340 1250 0 0 {name=p112 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} -1340 1230 0 0 {name=p113 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1190 1400 0 0 {name=p114 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -1180 1605 0 0 {name=x11}
C {lab_wire.sym} -1180 1435 0 0 {name=p115 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -1340 1575 0 0 {name=p118 sig_type=std_logic lab=a7_not}
C {lab_wire.sym} -1340 1555 0 0 {name=p119 sig_type=std_logic lab=a7}
C {lab_wire.sym} -1340 1615 0 0 {name=p120 sig_type=std_logic lab=b1_not}
C {lab_wire.sym} -1340 1595 0 0 {name=p121 sig_type=std_logic lab=b1}
C {lab_wire.sym} -1190 1765 0 0 {name=p122 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -722.5 -965 0 0 {name=x13}
C {lab_wire.sym} -882.5 -995 0 0 {name=p134 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} -882.5 -1015 0 0 {name=p135 sig_type=std_logic lab=a1}
C {lab_wire.sym} -882.5 -955 0 0 {name=p136 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -882.5 -975 0 0 {name=p137 sig_type=std_logic lab=b0}
C {lab_wire.sym} -732.5 -805 0 0 {name=p138 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -722.5 -600 0 0 {name=x14}
C {lab_wire.sym} -722.5 -770 0 0 {name=p139 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -882.5 -630 0 0 {name=p142 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} -882.5 -650 0 0 {name=p143 sig_type=std_logic lab=a2}
C {lab_wire.sym} -882.5 -590 0 0 {name=p144 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -882.5 -610 0 0 {name=p145 sig_type=std_logic lab=b0}
C {lab_wire.sym} -732.5 -440 0 0 {name=p146 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -722.5 -235 0 0 {name=x15}
C {lab_wire.sym} -722.5 -405 0 0 {name=p147 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -882.5 -265 0 0 {name=p150 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} -882.5 -285 0 0 {name=p151 sig_type=std_logic lab=a3}
C {lab_wire.sym} -882.5 -225 0 0 {name=p152 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -882.5 -245 0 0 {name=p153 sig_type=std_logic lab=b0}
C {lab_wire.sym} -732.5 -75 0 0 {name=p154 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -722.5 142.5 0 0 {name=x16}
C {lab_wire.sym} -722.5 -27.5 0 0 {name=p155 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -882.5 112.5 0 0 {name=p158 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} -882.5 92.5 0 0 {name=p159 sig_type=std_logic lab=a4}
C {lab_wire.sym} -882.5 152.5 0 0 {name=p160 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -882.5 132.5 0 0 {name=p161 sig_type=std_logic lab=b0}
C {lab_wire.sym} -732.5 302.5 0 0 {name=p162 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -722.5 507.5 0 0 {name=x17}
C {lab_wire.sym} -722.5 337.5 0 0 {name=p163 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -882.5 477.5 0 0 {name=p166 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} -882.5 457.5 0 0 {name=p167 sig_type=std_logic lab=a5}
C {lab_wire.sym} -882.5 517.5 0 0 {name=p168 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -882.5 497.5 0 0 {name=p169 sig_type=std_logic lab=b0}
C {lab_wire.sym} -732.5 667.5 0 0 {name=p170 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -722.5 872.5 0 0 {name=x18}
C {lab_wire.sym} -722.5 702.5 0 0 {name=p171 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -882.5 842.5 0 0 {name=p174 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} -882.5 822.5 0 0 {name=p175 sig_type=std_logic lab=a6}
C {lab_wire.sym} -882.5 882.5 0 0 {name=p176 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -882.5 862.5 0 0 {name=p177 sig_type=std_logic lab=b0}
C {lab_wire.sym} -732.5 1032.5 0 0 {name=p178 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} -722.5 1237.5 0 0 {name=x19}
C {lab_wire.sym} -722.5 1067.5 0 0 {name=p179 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -882.5 1207.5 0 0 {name=p182 sig_type=std_logic lab=a7_not}
C {lab_wire.sym} -882.5 1187.5 0 0 {name=p183 sig_type=std_logic lab=a7}
C {lab_wire.sym} -882.5 1247.5 0 0 {name=p184 sig_type=std_logic lab=b0_not}
C {lab_wire.sym} -882.5 1227.5 0 0 {name=p185 sig_type=std_logic lab=b0}
C {lab_wire.sym} -732.5 1397.5 0 0 {name=p186 sig_type=std_logic lab=vss}
C {lab_wire.sym} -722.5 -1135 0 0 {name=p123 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -562.5 -935 0 0 {name=p126 sig_type=std_logic lab=b0_r1}
C {lab_wire.sym} -562.5 -915 0 0 {name=p127 sig_type=std_logic lab=b0_r1_not}
C {lab_wire.sym} -42.5 -610 0 0 {name=p124 sig_type=std_logic lab=b0_r1}
C {lab_wire.sym} -42.5 -590 0 0 {name=p125 sig_type=std_logic lab=b0_r1_not}
C {lab_wire.sym} -42.5 -650 0 0 {name=p128 sig_type=std_logic lab=b1_r0}
C {lab_wire.sym} -42.5 -630 0 0 {name=p129 sig_type=std_logic lab=b1_r0_not}
C {lab_wire.sym} -1020 -932.5 0 0 {name=p130 sig_type=std_logic lab=b1_r0}
C {lab_wire.sym} -1020 -912.5 0 0 {name=p131 sig_type=std_logic lab=b1_r0_not}
C {lab_wire.sym} -562.5 -570 0 0 {name=p187 sig_type=std_logic lab=b0_r2}
C {lab_wire.sym} -562.5 -550 0 0 {name=p188 sig_type=std_logic lab=b0_r2_not}
C {lab_wire.sym} -1020 -567.5 0 0 {name=p189 sig_type=std_logic lab=b1_r1}
C {lab_wire.sym} -1020 -547.5 0 0 {name=p190 sig_type=std_logic lab=b1_r1_not}
C {lab_wire.sym} -562.5 -205 0 0 {name=p191 sig_type=std_logic lab=b0_r3}
C {lab_wire.sym} -562.5 -185 0 0 {name=p192 sig_type=std_logic lab=b0_r3_not}
C {lab_wire.sym} -1020 -202.5 0 0 {name=p193 sig_type=std_logic lab=b1_r2}
C {lab_wire.sym} -1020 -182.5 0 0 {name=p194 sig_type=std_logic lab=b1_r2_not}
C {lab_wire.sym} -562.5 172.5 0 0 {name=p195 sig_type=std_logic lab=b0_r4}
C {lab_wire.sym} -562.5 192.5 0 0 {name=p196 sig_type=std_logic lab=b0_r4_not}
C {lab_wire.sym} -1020 162.5 0 0 {name=p197 sig_type=std_logic lab=b1_r3}
C {lab_wire.sym} -1020 182.5 0 0 {name=p198 sig_type=std_logic lab=b1_r3_not}
C {lab_wire.sym} -562.5 537.5 0 0 {name=p199 sig_type=std_logic lab=b0_r5}
C {lab_wire.sym} -562.5 557.5 0 0 {name=p200 sig_type=std_logic lab=b0_r5_not}
C {lab_wire.sym} -1020 540 0 0 {name=p201 sig_type=std_logic lab=b1_r4}
C {lab_wire.sym} -1020 560 0 0 {name=p202 sig_type=std_logic lab=b1_r4_not}
C {lab_wire.sym} -562.5 902.5 0 0 {name=p203 sig_type=std_logic lab=b0_r6}
C {lab_wire.sym} -562.5 922.5 0 0 {name=p204 sig_type=std_logic lab=b0_r6_not}
C {lab_wire.sym} -562.5 1267.5 0 0 {name=p205 sig_type=std_logic lab=b0_r7}
C {lab_wire.sym} -562.5 1287.5 0 0 {name=p206 sig_type=std_logic lab=b0_r7_not}
C {lab_wire.sym} -1020 905 0 0 {name=p207 sig_type=std_logic lab=b1_r5}
C {lab_wire.sym} -1020 925 0 0 {name=p208 sig_type=std_logic lab=b1_r5_not}
C {lab_wire.sym} -1020 1270 0 0 {name=p209 sig_type=std_logic lab=b1_r6}
C {lab_wire.sym} -1020 1290 0 0 {name=p210 sig_type=std_logic lab=b1_r6_not}
C {lab_wire.sym} -1020 1635 0 0 {name=p211 sig_type=std_logic lab=b1_r7}
C {lab_wire.sym} -1020 1655 0 0 {name=p212 sig_type=std_logic lab=b1_r7_not}
C {lab_wire.sym} -42.5 -530 0 0 {name=p213 sig_type=std_logic lab=b0_r2}
C {lab_wire.sym} -42.5 -510 0 0 {name=p214 sig_type=std_logic lab=b0_r2_not}
C {lab_wire.sym} -42.5 -570 0 0 {name=p215 sig_type=std_logic lab=b1_r1}
C {lab_wire.sym} -42.5 -550 0 0 {name=p216 sig_type=std_logic lab=b1_r1_not}
C {lab_wire.sym} -42.5 -450 0 0 {name=p217 sig_type=std_logic lab=b0_r3}
C {lab_wire.sym} -42.5 -430 0 0 {name=p218 sig_type=std_logic lab=b0_r3_not}
C {lab_wire.sym} -42.5 -490 0 0 {name=p219 sig_type=std_logic lab=b1_r2}
C {lab_wire.sym} -42.5 -470 0 0 {name=p220 sig_type=std_logic lab=b1_r2_not}
C {lab_wire.sym} -42.5 -370 0 0 {name=p221 sig_type=std_logic lab=b0_r4}
C {lab_wire.sym} -42.5 -350 0 0 {name=p222 sig_type=std_logic lab=b0_r4_not}
C {lab_wire.sym} -42.5 -410 0 0 {name=p223 sig_type=std_logic lab=b1_r3}
C {lab_wire.sym} -42.5 -390 0 0 {name=p224 sig_type=std_logic lab=b1_r3_not}
C {lab_wire.sym} -42.5 -290 0 0 {name=p225 sig_type=std_logic lab=b0_r5}
C {lab_wire.sym} -42.5 -270 0 0 {name=p226 sig_type=std_logic lab=b0_r5_not}
C {lab_wire.sym} -42.5 -330 0 0 {name=p227 sig_type=std_logic lab=b1_r4}
C {lab_wire.sym} -42.5 -310 0 0 {name=p228 sig_type=std_logic lab=b1_r4_not}
C {lab_wire.sym} -42.5 -210 0 0 {name=p229 sig_type=std_logic lab=b0_r6}
C {lab_wire.sym} -42.5 -190 0 0 {name=p230 sig_type=std_logic lab=b0_r6_not}
C {lab_wire.sym} -42.5 -250 0 0 {name=p231 sig_type=std_logic lab=b1_r5}
C {lab_wire.sym} -42.5 -230 0 0 {name=p232 sig_type=std_logic lab=b1_r5_not}
C {lab_wire.sym} -42.5 -130 0 0 {name=p233 sig_type=std_logic lab=b0_r7}
C {lab_wire.sym} -42.5 -110 0 0 {name=p234 sig_type=std_logic lab=b0_r7_not}
C {lab_wire.sym} -42.5 -170 0 0 {name=p235 sig_type=std_logic lab=b1_r6}
C {lab_wire.sym} -42.5 -150 0 0 {name=p236 sig_type=std_logic lab=b1_r6_not}
C {lab_wire.sym} -42.5 -90 0 0 {name=p237 sig_type=std_logic lab=b1_r7}
C {lab_wire.sym} -42.5 -70 0 0 {name=p238 sig_type=std_logic lab=b1_r7_not}
C {iopin.sym} 290 -930 0 0 {name=p241 lab=p0}
C {iopin.sym} 290 -910 0 0 {name=p242 lab=p0_not}
C {iopin.sym} 290 -650 0 0 {name=p53 lab=p1}
C {iopin.sym} 290 -630 0 0 {name=p54 lab=p1_not}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 1367.5 -562.5 0 0 {name=x12}
C {lab_wire.sym} 1367.5 -732.5 0 0 {name=p243 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1207.5 -592.5 0 0 {name=p246 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} 1207.5 -612.5 0 0 {name=p247 sig_type=std_logic lab=a0}
C {lab_wire.sym} 1207.5 -552.5 0 0 {name=p248 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} 1207.5 -572.5 0 0 {name=p249 sig_type=std_logic lab=b2}
C {lab_wire.sym} 1357.5 -402.5 0 0 {name=p250 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 1367.5 -197.5 0 0 {name=x20}
C {lab_wire.sym} 1367.5 -367.5 0 0 {name=p251 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1207.5 -227.5 0 0 {name=p254 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} 1207.5 -247.5 0 0 {name=p255 sig_type=std_logic lab=a1}
C {lab_wire.sym} 1207.5 -187.5 0 0 {name=p256 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} 1207.5 -207.5 0 0 {name=p257 sig_type=std_logic lab=b2}
C {lab_wire.sym} 1357.5 -37.5 0 0 {name=p258 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 1367.5 167.5 0 0 {name=x21}
C {lab_wire.sym} 1367.5 -2.5 0 0 {name=p259 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1207.5 137.5 0 0 {name=p262 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} 1207.5 117.5 0 0 {name=p263 sig_type=std_logic lab=a2}
C {lab_wire.sym} 1207.5 177.5 0 0 {name=p264 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} 1207.5 157.5 0 0 {name=p265 sig_type=std_logic lab=b2}
C {lab_wire.sym} 1357.5 327.5 0 0 {name=p266 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 1367.5 532.5 0 0 {name=x22}
C {lab_wire.sym} 1367.5 362.5 0 0 {name=p267 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1207.5 502.5 0 0 {name=p270 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} 1207.5 482.5 0 0 {name=p271 sig_type=std_logic lab=a3}
C {lab_wire.sym} 1207.5 542.5 0 0 {name=p272 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} 1207.5 522.5 0 0 {name=p273 sig_type=std_logic lab=b2}
C {lab_wire.sym} 1357.5 692.5 0 0 {name=p274 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 1367.5 910 0 0 {name=x23}
C {lab_wire.sym} 1367.5 740 0 0 {name=p275 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1207.5 880 0 0 {name=p278 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} 1207.5 860 0 0 {name=p279 sig_type=std_logic lab=a4}
C {lab_wire.sym} 1207.5 920 0 0 {name=p280 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} 1207.5 900 0 0 {name=p281 sig_type=std_logic lab=b2}
C {lab_wire.sym} 1357.5 1070 0 0 {name=p282 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 1367.5 1275 0 0 {name=x24}
C {lab_wire.sym} 1367.5 1105 0 0 {name=p283 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1207.5 1245 0 0 {name=p286 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} 1207.5 1225 0 0 {name=p287 sig_type=std_logic lab=a5}
C {lab_wire.sym} 1207.5 1285 0 0 {name=p288 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} 1207.5 1265 0 0 {name=p289 sig_type=std_logic lab=b2}
C {lab_wire.sym} 1357.5 1435 0 0 {name=p290 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 1367.5 1640 0 0 {name=x25}
C {lab_wire.sym} 1367.5 1470 0 0 {name=p291 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1207.5 1610 0 0 {name=p294 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} 1207.5 1590 0 0 {name=p295 sig_type=std_logic lab=a6}
C {lab_wire.sym} 1207.5 1650 0 0 {name=p296 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} 1207.5 1630 0 0 {name=p297 sig_type=std_logic lab=b2}
C {lab_wire.sym} 1357.5 1800 0 0 {name=p298 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 1367.5 2005 0 0 {name=x26}
C {lab_wire.sym} 1367.5 1835 0 0 {name=p299 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1207.5 1975 0 0 {name=p302 sig_type=std_logic lab=a7_not}
C {lab_wire.sym} 1207.5 1955 0 0 {name=p303 sig_type=std_logic lab=a7}
C {lab_wire.sym} 1207.5 2015 0 0 {name=p304 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} 1207.5 1995 0 0 {name=p305 sig_type=std_logic lab=b2}
C {lab_wire.sym} 1357.5 2165 0 0 {name=p306 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1527.5 -532.5 0 0 {name=p307 sig_type=std_logic lab=b2_r0}
C {lab_wire.sym} 1527.5 -512.5 0 0 {name=p308 sig_type=std_logic lab=b2_r0_not}
C {lab_wire.sym} 1527.5 -167.5 0 0 {name=p309 sig_type=std_logic lab=b2_r1}
C {lab_wire.sym} 1527.5 -147.5 0 0 {name=p310 sig_type=std_logic lab=b2_r1_not}
C {lab_wire.sym} 1527.5 197.5 0 0 {name=p311 sig_type=std_logic lab=b2_r2}
C {lab_wire.sym} 1527.5 217.5 0 0 {name=p312 sig_type=std_logic lab=b2_r2_not}
C {lab_wire.sym} 1527.5 562.5 0 0 {name=p313 sig_type=std_logic lab=b2_r3}
C {lab_wire.sym} 1527.5 582.5 0 0 {name=p314 sig_type=std_logic lab=b2_r3_not}
C {lab_wire.sym} 1527.5 940 0 0 {name=p315 sig_type=std_logic lab=b2_r4}
C {lab_wire.sym} 1527.5 960 0 0 {name=p316 sig_type=std_logic lab=b2_r4_not}
C {lab_wire.sym} 1527.5 1305 0 0 {name=p317 sig_type=std_logic lab=b2_r5}
C {lab_wire.sym} 1527.5 1325 0 0 {name=p318 sig_type=std_logic lab=b2_r5_not}
C {lab_wire.sym} 1527.5 1670 0 0 {name=p319 sig_type=std_logic lab=b2_r6}
C {lab_wire.sym} 1527.5 1690 0 0 {name=p320 sig_type=std_logic lab=b2_r6_not}
C {lab_wire.sym} 1527.5 2035 0 0 {name=p321 sig_type=std_logic lab=b2_r7}
C {lab_wire.sym} 1527.5 2055 0 0 {name=p322 sig_type=std_logic lab=b2_r7_not}
C {iopin.sym} 290 -610 0 0 {name=p323 lab=b0_r1_b}
C {iopin.sym} 290 -590 0 0 {name=p324 lab=b0_r1_b_not}
C {iopin.sym} 290 -970 0 0 {name=p327 lab=b0_q0}
C {iopin.sym} 290 -950 0 0 {name=p328 lab=b0_q0_not}
C {iopin.sym} 290 -1010 0 0 {name=p329 lab=b0_p0}
C {iopin.sym} 290 -990 0 0 {name=p330 lab=b0_p0_not}
C {iopin.sym} -562.5 -975 0 0 {name=p331 lab=b0_q1}
C {iopin.sym} -562.5 -955 0 0 {name=p332 lab=b0_q1_not}
C {iopin.sym} -562.5 -1015 0 0 {name=p333 lab=b0_p1}
C {iopin.sym} -562.5 -995 0 0 {name=p334 lab=b0_p1_not}
C {iopin.sym} -562.5 -610 0 0 {name=p335 lab=b0_q2}
C {iopin.sym} -562.5 -590 0 0 {name=p336 lab=b0_q2_not}
C {iopin.sym} -562.5 -650 0 0 {name=p337 lab=b0_p2}
C {iopin.sym} -562.5 -630 0 0 {name=p338 lab=b0_p2_not}
C {iopin.sym} -562.5 -245 0 0 {name=p339 lab=b0_q3}
C {iopin.sym} -562.5 -225 0 0 {name=p340 lab=b0_q3_not}
C {iopin.sym} -562.5 -285 0 0 {name=p341 lab=b0_p3}
C {iopin.sym} -562.5 -265 0 0 {name=p342 lab=b0_p3_not}
C {iopin.sym} -562.5 132.5 0 0 {name=p343 lab=b0_q4}
C {iopin.sym} -562.5 152.5 0 0 {name=p344 lab=b0_q4_not}
C {iopin.sym} -562.5 92.5 0 0 {name=p345 lab=b0_p4}
C {iopin.sym} -562.5 112.5 0 0 {name=p346 lab=b0_p4_not}
C {iopin.sym} -562.5 497.5 0 0 {name=p347 lab=b0_q5}
C {iopin.sym} -562.5 517.5 0 0 {name=p348 lab=b0_q5_not}
C {iopin.sym} -562.5 457.5 0 0 {name=p349 lab=b0_p5}
C {iopin.sym} -562.5 477.5 0 0 {name=p350 lab=b0_p5_not}
C {iopin.sym} -562.5 862.5 0 0 {name=p351 lab=b0_q6}
C {iopin.sym} -562.5 882.5 0 0 {name=p352 lab=b0_q6_not}
C {iopin.sym} -562.5 822.5 0 0 {name=p353 lab=b0_p6}
C {iopin.sym} -562.5 842.5 0 0 {name=p354 lab=b0_p6_not}
C {iopin.sym} -562.5 1227.5 0 0 {name=p355 lab=b0_q7}
C {iopin.sym} -562.5 1247.5 0 0 {name=p356 lab=b0_q7_not}
C {iopin.sym} -562.5 1187.5 0 0 {name=p357 lab=b0_p7}
C {iopin.sym} -562.5 1207.5 0 0 {name=p358 lab=b0_p7_not}
C {iopin.sym} -1020 1595 0 0 {name=p359 lab=b1_q7}
C {iopin.sym} -1020 1615 0 0 {name=p360 lab=b1_q7_not}
C {iopin.sym} -1020 1555 0 0 {name=p361 lab=b1_p7}
C {iopin.sym} -1020 1575 0 0 {name=p362 lab=b1_p7_not}
C {iopin.sym} -1020 1230 0 0 {name=p363 lab=b1_q6}
C {iopin.sym} -1020 1250 0 0 {name=p364 lab=b1_q6_not}
C {iopin.sym} -1020 1190 0 0 {name=p365 lab=b1_p6}
C {iopin.sym} -1020 1210 0 0 {name=p366 lab=b1_p6_not}
C {iopin.sym} -1020 865 0 0 {name=p367 lab=b1_q5}
C {iopin.sym} -1020 885 0 0 {name=p368 lab=b1_q5_not}
C {iopin.sym} -1020 825 0 0 {name=p369 lab=b1_p5}
C {iopin.sym} -1020 845 0 0 {name=p370 lab=b1_p5_not}
C {iopin.sym} -1020 500 0 0 {name=p371 lab=b1_q4}
C {iopin.sym} -1020 520 0 0 {name=p372 lab=b1_q4_not}
C {iopin.sym} -1020 460 0 0 {name=p373 lab=b1_p4}
C {iopin.sym} -1020 480 0 0 {name=p374 lab=b1_p4_not}
C {iopin.sym} -1020 122.5 0 0 {name=p375 lab=b1_q3}
C {iopin.sym} -1020 142.5 0 0 {name=p376 lab=b1_q3_not}
C {iopin.sym} -1020 82.5 0 0 {name=p377 lab=b1_p3}
C {iopin.sym} -1020 102.5 0 0 {name=p378 lab=b1_p3_not}
C {iopin.sym} -1020 -242.5 0 0 {name=p379 lab=b1_q2}
C {iopin.sym} -1020 -222.5 0 0 {name=p380 lab=b1_q2_not}
C {iopin.sym} -1020 -282.5 0 0 {name=p381 lab=b1_p2}
C {iopin.sym} -1020 -262.5 0 0 {name=p382 lab=b1_p2_not}
C {iopin.sym} -1020 -607.5 0 0 {name=p383 lab=b1_q1}
C {iopin.sym} -1020 -587.5 0 0 {name=p384 lab=b1_q1_not}
C {iopin.sym} -1020 -647.5 0 0 {name=p385 lab=b1_p1}
C {iopin.sym} -1020 -627.5 0 0 {name=p386 lab=b1_p1_not}
C {iopin.sym} -1020 -972.5 0 0 {name=p387 lab=b1_q0}
C {iopin.sym} -1020 -952.5 0 0 {name=p388 lab=b1_q0_not}
C {iopin.sym} -1020 -1012.5 0 0 {name=p389 lab=b1_p0}
C {iopin.sym} -1020 -992.5 0 0 {name=p390 lab=b1_p0_not}
C {iopin.sym} -1340 -932.5 2 0 {name=p391 lab=b1_c0}
C {iopin.sym} -1340 -912.5 2 0 {name=p392 lab=b1_c0_not}
C {iopin.sym} -1340 -567.5 2 0 {name=p56 lab=b1_c1}
C {iopin.sym} -1340 -547.5 2 0 {name=p61 lab=b1_c1_not}
C {iopin.sym} -1340 -202.5 2 0 {name=p68 lab=b1_c2}
C {iopin.sym} -1340 -182.5 2 0 {name=p69 lab=b1_c2_not}
C {iopin.sym} -1340 162.5 2 0 {name=p76 lab=b1_c3}
C {iopin.sym} -1340 182.5 2 0 {name=p77 lab=b1_c3_not}
C {iopin.sym} -1340 540 2 0 {name=p84 lab=b1_c4}
C {iopin.sym} -1340 560 2 0 {name=p85 lab=b1_c4_not}
C {iopin.sym} -1340 905 2 0 {name=p92 lab=b1_c5}
C {iopin.sym} -1340 925 2 0 {name=p93 lab=b1_c5_not}
C {iopin.sym} -1340 1270 2 0 {name=p100 lab=b1_c6}
C {iopin.sym} -1340 1290 2 0 {name=p101 lab=b1_c6_not}
C {iopin.sym} -1340 1635 2 0 {name=p108 lab=b1_c7}
C {iopin.sym} -1340 1655 2 0 {name=p109 lab=b1_c7_not}
C {iopin.sym} -882.5 1267.5 2 0 {name=p116 lab=b0_c7}
C {iopin.sym} -882.5 1287.5 2 0 {name=p117 lab=b0_c7_not}
C {iopin.sym} -882.5 902.5 2 0 {name=p180 lab=b0_c6}
C {iopin.sym} -882.5 922.5 2 0 {name=p181 lab=b0_c6_not}
C {iopin.sym} -882.5 537.5 2 0 {name=p172 lab=b0_c5}
C {iopin.sym} -882.5 557.5 2 0 {name=p173 lab=b0_c5_not}
C {iopin.sym} -882.5 172.5 2 0 {name=p164 lab=b0_c4}
C {iopin.sym} -882.5 192.5 2 0 {name=p165 lab=b0_c4_not}
C {iopin.sym} -882.5 -205 2 0 {name=p148 lab=b0_c3}
C {iopin.sym} -882.5 -185 2 0 {name=p149 lab=b0_c3_not}
C {iopin.sym} -882.5 -570 2 0 {name=p140 lab=b0_c2}
C {iopin.sym} -882.5 -550 2 0 {name=p141 lab=b0_c2_not}
C {iopin.sym} -882.5 -935 2 0 {name=p156 lab=b0_c1}
C {iopin.sym} -882.5 -915 2 0 {name=p157 lab=b0_c1_not}
C {iopin.sym} -30 -930 2 0 {name=p47 lab=b0_c0}
C {iopin.sym} -30 -910 2 0 {name=p48 lab=b0_c0_not}
C {iopin.sym} 1207.5 -532.5 2 0 {name=p132 lab=b2_c0}
C {iopin.sym} 1207.5 -512.5 2 0 {name=p133 lab=b2_c0_not}
C {iopin.sym} 1527.5 -572.5 0 0 {name=p244 lab=b2_q0}
C {iopin.sym} 1527.5 -552.5 0 0 {name=p245 lab=b2_q0_not}
C {iopin.sym} 1527.5 -612.5 0 0 {name=p393 lab=b2_p0}
C {iopin.sym} 1527.5 -592.5 0 0 {name=p394 lab=b2_p0_not}
C {iopin.sym} 1527.5 -207.5 0 0 {name=p252 lab=b2_q1}
C {iopin.sym} 1527.5 -187.5 0 0 {name=p253 lab=b2_q1_not}
C {iopin.sym} 1527.5 -247.5 0 0 {name=p395 lab=b2_p1}
C {iopin.sym} 1527.5 -227.5 0 0 {name=p396 lab=b2_p1_not}
C {iopin.sym} 1207.5 -167.5 2 0 {name=p397 lab=b2_c1}
C {iopin.sym} 1207.5 -147.5 2 0 {name=p398 lab=b2_c1_not}
C {iopin.sym} 1527.5 157.5 0 0 {name=p399 lab=b2_q2}
C {iopin.sym} 1527.5 177.5 0 0 {name=p400 lab=b2_q2_not}
C {iopin.sym} 1527.5 117.5 0 0 {name=p401 lab=b2_p2}
C {iopin.sym} 1527.5 137.5 0 0 {name=p402 lab=b2_p2_not}
C {iopin.sym} 1527.5 522.5 0 0 {name=p403 lab=b2_q3}
C {iopin.sym} 1527.5 542.5 0 0 {name=p404 lab=b2_q3_not}
C {iopin.sym} 1527.5 482.5 0 0 {name=p405 lab=b2_p3}
C {iopin.sym} 1527.5 502.5 0 0 {name=p406 lab=b2_p3_not}
C {iopin.sym} 1527.5 900 0 0 {name=p407 lab=b2_q4}
C {iopin.sym} 1527.5 920 0 0 {name=p408 lab=b2_q4_not}
C {iopin.sym} 1527.5 860 0 0 {name=p409 lab=b2_p4}
C {iopin.sym} 1527.5 880 0 0 {name=p410 lab=b2_p4_not}
C {iopin.sym} 1527.5 1265 0 0 {name=p411 lab=b2_q5}
C {iopin.sym} 1527.5 1285 0 0 {name=p412 lab=b2_q5_not}
C {iopin.sym} 1527.5 1225 0 0 {name=p413 lab=b2_p5}
C {iopin.sym} 1527.5 1245 0 0 {name=p414 lab=b2_p5_not}
C {iopin.sym} 1527.5 1630 0 0 {name=p415 lab=b2_q6}
C {iopin.sym} 1527.5 1650 0 0 {name=p416 lab=b2_q6_not}
C {iopin.sym} 1527.5 1590 0 0 {name=p417 lab=b2_p6}
C {iopin.sym} 1527.5 1610 0 0 {name=p418 lab=b2_p6_not}
C {iopin.sym} 1527.5 1995 0 0 {name=p419 lab=b2_q7}
C {iopin.sym} 1527.5 2015 0 0 {name=p420 lab=b2_q7_not}
C {iopin.sym} 1527.5 1955 0 0 {name=p421 lab=b2_p7}
C {iopin.sym} 1527.5 1975 0 0 {name=p422 lab=b2_p7_not}
C {iopin.sym} 1207.5 562.5 2 0 {name=p268 lab=b2_c3}
C {iopin.sym} 1207.5 582.5 2 0 {name=p269 lab=b2_c3_not}
C {iopin.sym} 1207.5 940 2 0 {name=p276 lab=b2_c4}
C {iopin.sym} 1207.5 960 2 0 {name=p277 lab=b2_c4_not}
C {iopin.sym} 1207.5 1305 2 0 {name=p284 lab=b2_c5}
C {iopin.sym} 1207.5 1325 2 0 {name=p285 lab=b2_c5_not}
C {iopin.sym} 1207.5 1670 2 0 {name=p423 lab=b2_c6}
C {iopin.sym} 1207.5 1690 2 0 {name=p424 lab=b2_c6_not}
C {iopin.sym} 1207.5 2035 2 0 {name=p292 lab=b2_c7}
C {iopin.sym} 1207.5 2055 2 0 {name=p293 lab=b2_c7_not}
C {lab_wire.sym} 2070 -700 0 0 {name=p300 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2070 110 0 0 {name=p301 sig_type=std_logic lab=vss}
C {lab_wire.sym} 290 -570 0 0 {name=p427 sig_type=std_logic lab=x0_s1}
C {lab_wire.sym} 290 -550 0 0 {name=p428 sig_type=std_logic lab=x0_s1_not}
C {lab_wire.sym} 1910 -590 0 0 {name=p429 sig_type=std_logic lab=b2_r0}
C {lab_wire.sym} 1910 -570 0 0 {name=p430 sig_type=std_logic lab=b2_r0_not}
C {lab_wire.sym} 1910 -630 0 0 {name=p431 sig_type=std_logic lab=x0_s1}
C {lab_wire.sym} 1910 -610 0 0 {name=p432 sig_type=std_logic lab=x0_s1_not}
C {iopin.sym} -40 -690 2 0 {name=p7 lab=x0_c0_f}
C {iopin.sym} -40 -670 2 0 {name=p8 lab=x0_c0_f_not}
C {iopin.sym} 1900 -670 2 0 {name=p433 lab=x1_c0_f}
C {iopin.sym} 1900 -650 2 0 {name=p434 lab=x1_c0_f_not}
C {lab_wire.sym} 1910 -510 0 0 {name=p435 sig_type=std_logic lab=b2_r1}
C {lab_wire.sym} 1910 -490 0 0 {name=p436 sig_type=std_logic lab=b2_r1_not}
C {lab_wire.sym} 1910 -550 0 0 {name=p437 sig_type=std_logic lab=x0_s2}
C {lab_wire.sym} 1910 -530 0 0 {name=p438 sig_type=std_logic lab=x0_s2_not}
C {lab_wire.sym} 290 -490 0 0 {name=p439 sig_type=std_logic lab=x0_s2}
C {lab_wire.sym} 290 -470 0 0 {name=p440 sig_type=std_logic lab=x0_s2_not}
C {lab_wire.sym} 1910 -430 0 0 {name=p441 sig_type=std_logic lab=b2_r2}
C {lab_wire.sym} 1910 -410 0 0 {name=p442 sig_type=std_logic lab=b2_r2_not}
C {lab_wire.sym} 1910 -470 0 0 {name=p443 sig_type=std_logic lab=x0_s3}
C {lab_wire.sym} 1910 -450 0 0 {name=p444 sig_type=std_logic lab=x0_s3_not}
C {lab_wire.sym} 1910 -350 0 0 {name=p445 sig_type=std_logic lab=b2_r3}
C {lab_wire.sym} 1910 -330 0 0 {name=p446 sig_type=std_logic lab=b2_r3_not}
C {lab_wire.sym} 1910 -390 0 0 {name=p447 sig_type=std_logic lab=x0_s4}
C {lab_wire.sym} 1910 -370 0 0 {name=p448 sig_type=std_logic lab=x0_s4_not}
C {lab_wire.sym} 1910 -270 0 0 {name=p449 sig_type=std_logic lab=b2_r4}
C {lab_wire.sym} 1910 -250 0 0 {name=p450 sig_type=std_logic lab=b2_r4_not}
C {lab_wire.sym} 1910 -310 0 0 {name=p451 sig_type=std_logic lab=x0_s5}
C {lab_wire.sym} 1910 -290 0 0 {name=p452 sig_type=std_logic lab=x0_s5_not}
C {lab_wire.sym} 1910 -190 0 0 {name=p453 sig_type=std_logic lab=b2_r5}
C {lab_wire.sym} 1910 -170 0 0 {name=p454 sig_type=std_logic lab=b2_r5_not}
C {lab_wire.sym} 1910 -230 0 0 {name=p455 sig_type=std_logic lab=x0_s6}
C {lab_wire.sym} 1910 -210 0 0 {name=p456 sig_type=std_logic lab=x0_s6_not}
C {lab_wire.sym} 1910 -110 0 0 {name=p457 sig_type=std_logic lab=b2_r6}
C {lab_wire.sym} 1910 -90 0 0 {name=p458 sig_type=std_logic lab=b2_r6_not}
C {lab_wire.sym} 1910 -150 0 0 {name=p459 sig_type=std_logic lab=x0_s7}
C {lab_wire.sym} 1910 -130 0 0 {name=p460 sig_type=std_logic lab=x0_s7_not}
C {lab_wire.sym} 1910 -30 0 0 {name=p461 sig_type=std_logic lab=b2_r7}
C {lab_wire.sym} 1910 -10 0 0 {name=p462 sig_type=std_logic lab=b2_r7_not}
C {lab_wire.sym} 1910 -70 0 0 {name=p463 sig_type=std_logic lab=x0_s8}
C {lab_wire.sym} 1910 -50 0 0 {name=p464 sig_type=std_logic lab=x0_s8_not}
C {symbols/nfet_03v3.sym} 422.5 90 0 0 {name=M9
L=0.55u
W=1.37u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 712.5 90 2 0 {name=M10
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {iopin.sym} 352.5 270 2 0 {name=p325 lab=x0_b0_f}
C {lab_wire.sym} 492.5 90 2 0 {name=p326 sig_type=std_logic lab=vss}
C {lab_wire.sym} 642.5 90 0 0 {name=p465 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 422.5 210 0 0 {name=M11
L=0.55u
W=1.415u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 712.5 210 2 0 {name=M12
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 492.5 210 2 0 {name=p466 sig_type=std_logic lab=vss}
C {lab_wire.sym} 642.5 210 0 0 {name=p467 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 422.5 330 0 0 {name=M13
L=0.55u
W=1.365u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 712.5 330 2 0 {name=M14
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 492.5 330 2 0 {name=p468 sig_type=std_logic lab=vss}
C {lab_wire.sym} 642.5 330 0 0 {name=p469 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 422.5 450 0 0 {name=M15
L=0.55u
W=1.385u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 712.5 450 2 0 {name=M16
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 492.5 450 2 0 {name=p470 sig_type=std_logic lab=vss}
C {lab_wire.sym} 642.5 450 0 0 {name=p471 sig_type=std_logic lab=vdd}
C {iopin.sym} 352.5 510 2 0 {name=p472 lab=x0_b0_f_not
}
C {final_project/devices/8b_FA_ripple/8b_FA_ripple.sym} 130 -60 0 0 {name=x27}
C {iopin.sym} 290 -690 0 0 {name=p473 lab=x0_c0_b}
C {iopin.sym} 290 -670 0 0 {name=p474 lab=x0_c0_b_not}
C {iopin.sym} 290 -530 0 0 {name=p475 lab=b0_r2_b}
C {iopin.sym} 290 -510 0 0 {name=p476 lab=b0_r2_b_not}
C {iopin.sym} 290 -450 0 0 {name=p479 lab=b0_r3_b}
C {iopin.sym} 290 -430 0 0 {name=p480 lab=b0_r3_b_not}
C {iopin.sym} 290 -370 0 0 {name=p425 lab=b0_r4_b}
C {iopin.sym} 290 -350 0 0 {name=p426 lab=b0_r4_b_not}
C {iopin.sym} 290 -290 0 0 {name=p481 lab=b0_r5_b}
C {iopin.sym} 290 -270 0 0 {name=p483 lab=b0_r5_b_not}
C {iopin.sym} 290 -210 0 0 {name=p484 lab=b0_r6_b}
C {iopin.sym} 290 -190 0 0 {name=p485 lab=b0_r6_b_not}
C {iopin.sym} 290 -130 0 0 {name=p486 lab=b0_r7_b}
C {iopin.sym} 290 -110 0 0 {name=p487 lab=b0_r7_b_not}
C {iopin.sym} -42.5 -50 2 0 {name=p239 lab=x0_a7_f}
C {iopin.sym} -42.5 -30 2 0 {name=p240 lab=x0_a7_f_not}
C {iopin.sym} 290 -50 0 0 {name=p482 lab=x0_a7_b}
C {iopin.sym} 290 -30 0 0 {name=p488 lab=x0_a7_b_not}
C {lab_wire.sym} 290 -410 0 0 {name=p489 sig_type=std_logic lab=x0_s3}
C {lab_wire.sym} 290 -390 0 0 {name=p490 sig_type=std_logic lab=x0_s3_not}
C {lab_wire.sym} 290 -330 0 0 {name=p491 sig_type=std_logic lab=x0_s4}
C {lab_wire.sym} 290 -310 0 0 {name=p492 sig_type=std_logic lab=x0_s4_not}
C {lab_wire.sym} 290 -250 0 0 {name=p493 sig_type=std_logic lab=x0_s5}
C {lab_wire.sym} 290 -230 0 0 {name=p494 sig_type=std_logic lab=x0_s5_not}
C {lab_wire.sym} 290 -170 0 0 {name=p495 sig_type=std_logic lab=x0_s6}
C {lab_wire.sym} 290 -150 0 0 {name=p496 sig_type=std_logic lab=x0_s6_not}
C {lab_wire.sym} 290 -90 0 0 {name=p497 sig_type=std_logic lab=x0_s7}
C {lab_wire.sym} 290 -70 0 0 {name=p498 sig_type=std_logic lab=x0_s7_not}
C {lab_wire.sym} 792.5 130 0 0 {name=p499 sig_type=std_logic lab=x0_s8}
C {lab_wire.sym} 792.5 370 0 0 {name=p500 sig_type=std_logic lab=x0_s8_not}
C {final_project/devices/8b_FA_ripple/8b_FA_ripple.sym} 2070 -40 0 0 {name=x1}
C {symbols/nfet_03v3.sym} 2362.5 110 0 0 {name=M1
L=0.55u
W=1.37u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2652.5 110 2 0 {name=M2
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {iopin.sym} 2292.5 290 2 0 {name=p477 lab=x1_b0_f}
C {lab_wire.sym} 2432.5 110 2 0 {name=p478 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2582.5 110 0 0 {name=p501 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 2362.5 230 0 0 {name=M3
L=0.55u
W=1.415u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2652.5 230 2 0 {name=M4
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2432.5 230 2 0 {name=p502 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2582.5 230 0 0 {name=p503 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 2362.5 350 0 0 {name=M5
L=0.55u
W=1.365u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2652.5 350 2 0 {name=M6
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2432.5 350 2 0 {name=p504 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2582.5 350 0 0 {name=p505 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 2362.5 470 0 0 {name=M7
L=0.55u
W=1.385u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2652.5 470 2 0 {name=M8
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2432.5 470 2 0 {name=p506 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2582.5 470 0 0 {name=p507 sig_type=std_logic lab=vdd}
C {iopin.sym} 2292.5 530 2 0 {name=p508 lab=x1_b0_f_not
}
C {lab_wire.sym} 2732.5 150 0 0 {name=p509 sig_type=std_logic lab=x1_s8}
C {lab_wire.sym} 2732.5 390 0 0 {name=p510 sig_type=std_logic lab=x1_s8_not}
C {iopin.sym} 2230 -630 0 0 {name=p511 lab=p2}
C {iopin.sym} 2230 -610 0 0 {name=p512 lab=p2_not}
C {iopin.sym} 2230 -670 0 0 {name=p513 lab=x1_c0_b}
C {iopin.sym} 2230 -650 0 0 {name=p514 lab=x1_c0_b_not}
C {iopin.sym} 2230 -590 0 0 {name=p515 lab=b2_r0_b}
C {iopin.sym} 2230 -570 0 0 {name=p516 lab=b2_r0_b_not}
C {lab_wire.sym} 2230 -550 0 0 {name=p517 sig_type=std_logic lab=x1_s1}
C {lab_wire.sym} 2230 -530 0 0 {name=p518 sig_type=std_logic lab=x1_s1_not}
C {lab_wire.sym} 2230 -470 0 0 {name=p519 sig_type=std_logic lab=x1_s2}
C {lab_wire.sym} 2230 -450 0 0 {name=p520 sig_type=std_logic lab=x1_s2_not}
C {iopin.sym} 2230 -510 0 0 {name=p521 lab=b2_r1_b}
C {iopin.sym} 2230 -490 0 0 {name=p522 lab=b2_r1_b_not}
C {iopin.sym} 2230 -430 0 0 {name=p523 lab=b2_r2_b}
C {iopin.sym} 2230 -410 0 0 {name=p524 lab=b2_r2_b_not}
C {iopin.sym} 2230 -350 0 0 {name=p525 lab=b2_r3_b}
C {iopin.sym} 2230 -330 0 0 {name=p526 lab=b2_r3_b_not}
C {iopin.sym} 2230 -270 0 0 {name=p527 lab=b2_r4_b}
C {iopin.sym} 2230 -250 0 0 {name=p528 lab=b2_r4_b_not}
C {iopin.sym} 2230 -190 0 0 {name=p529 lab=b2_r5_b}
C {iopin.sym} 2230 -170 0 0 {name=p530 lab=b2_r5_b_not}
C {iopin.sym} 2230 -110 0 0 {name=p531 lab=b2_r6_b}
C {iopin.sym} 2230 -90 0 0 {name=p532 lab=b2_r6_b_not}
C {iopin.sym} 2230 -30 0 0 {name=p533 lab=b2_r7_b}
C {iopin.sym} 2230 -10 0 0 {name=p534 lab=b2_r7_b_not}
C {lab_wire.sym} 2230 -390 0 0 {name=p535 sig_type=std_logic lab=x1_s3}
C {lab_wire.sym} 2230 -370 0 0 {name=p536 sig_type=std_logic lab=x1_s3_not}
C {lab_wire.sym} 2230 -310 0 0 {name=p537 sig_type=std_logic lab=x1_s4}
C {lab_wire.sym} 2230 -290 0 0 {name=p538 sig_type=std_logic lab=x1_s4_not}
C {lab_wire.sym} 2230 -230 0 0 {name=p539 sig_type=std_logic lab=x1_s5}
C {lab_wire.sym} 2230 -210 0 0 {name=p540 sig_type=std_logic lab=x1_s5_not}
C {lab_wire.sym} 2230 -150 0 0 {name=p541 sig_type=std_logic lab=x1_s6}
C {lab_wire.sym} 2230 -130 0 0 {name=p542 sig_type=std_logic lab=x1_s6_not}
C {lab_wire.sym} 2230 -70 0 0 {name=p543 sig_type=std_logic lab=x1_s7}
C {lab_wire.sym} 2230 -50 0 0 {name=p544 sig_type=std_logic lab=x1_s7_not}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 3140 -562.5 0 0 {name=x3}
C {lab_wire.sym} 3140 -732.5 0 0 {name=p545 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2980 -592.5 0 0 {name=p546 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} 2980 -612.5 0 0 {name=p547 sig_type=std_logic lab=a0}
C {lab_wire.sym} 2980 -552.5 0 0 {name=p548 sig_type=std_logic lab=b3_not}
C {lab_wire.sym} 2980 -572.5 0 0 {name=p549 sig_type=std_logic lab=b3}
C {lab_wire.sym} 3130 -402.5 0 0 {name=p550 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 3140 -197.5 0 0 {name=x28}
C {lab_wire.sym} 3140 -367.5 0 0 {name=p551 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2980 -227.5 0 0 {name=p552 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} 2980 -247.5 0 0 {name=p553 sig_type=std_logic lab=a1}
C {lab_wire.sym} 2980 -187.5 0 0 {name=p554 sig_type=std_logic lab=b3_not}
C {lab_wire.sym} 2980 -207.5 0 0 {name=p555 sig_type=std_logic lab=b3}
C {lab_wire.sym} 3130 -37.5 0 0 {name=p556 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 3140 167.5 0 0 {name=x29}
C {lab_wire.sym} 3140 -2.5 0 0 {name=p557 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2980 137.5 0 0 {name=p560 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} 2980 117.5 0 0 {name=p561 sig_type=std_logic lab=a2}
C {lab_wire.sym} 2980 177.5 0 0 {name=p562 sig_type=std_logic lab=b3_not}
C {lab_wire.sym} 2980 157.5 0 0 {name=p563 sig_type=std_logic lab=b3}
C {lab_wire.sym} 3130 327.5 0 0 {name=p564 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 3140 532.5 0 0 {name=x30}
C {lab_wire.sym} 3140 362.5 0 0 {name=p565 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2980 502.5 0 0 {name=p566 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} 2980 482.5 0 0 {name=p567 sig_type=std_logic lab=a3}
C {lab_wire.sym} 2980 542.5 0 0 {name=p568 sig_type=std_logic lab=b3_not}
C {lab_wire.sym} 2980 522.5 0 0 {name=p569 sig_type=std_logic lab=b3}
C {lab_wire.sym} 3130 692.5 0 0 {name=p570 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 3140 910 0 0 {name=x31}
C {lab_wire.sym} 3140 740 0 0 {name=p571 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2980 880 0 0 {name=p572 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} 2980 860 0 0 {name=p573 sig_type=std_logic lab=a4}
C {lab_wire.sym} 2980 920 0 0 {name=p574 sig_type=std_logic lab=b3_not}
C {lab_wire.sym} 2980 900 0 0 {name=p575 sig_type=std_logic lab=b3}
C {lab_wire.sym} 3130 1070 0 0 {name=p576 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 3140 1275 0 0 {name=x32}
C {lab_wire.sym} 3140 1105 0 0 {name=p577 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2980 1245 0 0 {name=p578 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} 2980 1225 0 0 {name=p579 sig_type=std_logic lab=a5}
C {lab_wire.sym} 2980 1285 0 0 {name=p580 sig_type=std_logic lab=b3_not}
C {lab_wire.sym} 2980 1265 0 0 {name=p581 sig_type=std_logic lab=b3}
C {lab_wire.sym} 3130 1435 0 0 {name=p582 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 3140 1640 0 0 {name=x33}
C {lab_wire.sym} 3140 1470 0 0 {name=p583 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2980 1610 0 0 {name=p584 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} 2980 1590 0 0 {name=p585 sig_type=std_logic lab=a6}
C {lab_wire.sym} 2980 1650 0 0 {name=p586 sig_type=std_logic lab=b3_not}
C {lab_wire.sym} 2980 1630 0 0 {name=p587 sig_type=std_logic lab=b3}
C {lab_wire.sym} 3130 1800 0 0 {name=p588 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 3140 2005 0 0 {name=x34}
C {lab_wire.sym} 3140 1835 0 0 {name=p589 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2980 1975 0 0 {name=p590 sig_type=std_logic lab=a7_not}
C {lab_wire.sym} 2980 1955 0 0 {name=p591 sig_type=std_logic lab=a7}
C {lab_wire.sym} 2980 2015 0 0 {name=p592 sig_type=std_logic lab=b3_not}
C {lab_wire.sym} 2980 1995 0 0 {name=p593 sig_type=std_logic lab=b3}
C {lab_wire.sym} 3130 2165 0 0 {name=p594 sig_type=std_logic lab=vss}
C {lab_wire.sym} 3300 -532.5 0 0 {name=p595 sig_type=std_logic lab=b3_r0}
C {lab_wire.sym} 3300 -512.5 0 0 {name=p596 sig_type=std_logic lab=b3_r0_not}
C {lab_wire.sym} 3300 -167.5 0 0 {name=p597 sig_type=std_logic lab=b3_r1}
C {lab_wire.sym} 3300 -147.5 0 0 {name=p598 sig_type=std_logic lab=b3_r1_not}
C {lab_wire.sym} 3300 197.5 0 0 {name=p599 sig_type=std_logic lab=b3_r2}
C {lab_wire.sym} 3300 217.5 0 0 {name=p600 sig_type=std_logic lab=b3_r2_not}
C {lab_wire.sym} 3300 562.5 0 0 {name=p601 sig_type=std_logic lab=b3_r3}
C {lab_wire.sym} 3300 582.5 0 0 {name=p602 sig_type=std_logic lab=b3_r3_not}
C {lab_wire.sym} 3300 940 0 0 {name=p603 sig_type=std_logic lab=b3_r4}
C {lab_wire.sym} 3300 960 0 0 {name=p604 sig_type=std_logic lab=b3_r4_not}
C {lab_wire.sym} 3300 1305 0 0 {name=p605 sig_type=std_logic lab=b3_r5}
C {lab_wire.sym} 3300 1325 0 0 {name=p606 sig_type=std_logic lab=b3_r5_not}
C {lab_wire.sym} 3300 1670 0 0 {name=p607 sig_type=std_logic lab=b3_r6}
C {lab_wire.sym} 3300 1690 0 0 {name=p608 sig_type=std_logic lab=b3_r6_not}
C {lab_wire.sym} 3300 2035 0 0 {name=p609 sig_type=std_logic lab=b3_r7}
C {lab_wire.sym} 3300 2055 0 0 {name=p610 sig_type=std_logic lab=b3_r7_not}
C {iopin.sym} 2980 -532.5 2 0 {name=p611 lab=b3_c0}
C {iopin.sym} 2980 -512.5 2 0 {name=p612 lab=b3_c0_not}
C {iopin.sym} 3300 -572.5 0 0 {name=p613 lab=b3_q0}
C {iopin.sym} 3300 -552.5 0 0 {name=p614 lab=b3_q0_not}
C {iopin.sym} 3300 -612.5 0 0 {name=p615 lab=b3_p0}
C {iopin.sym} 3300 -592.5 0 0 {name=p616 lab=b3_p0_not}
C {iopin.sym} 3300 -207.5 0 0 {name=p617 lab=b3_q1}
C {iopin.sym} 3300 -187.5 0 0 {name=p618 lab=b3_q1_not}
C {iopin.sym} 3300 -247.5 0 0 {name=p619 lab=b3_p1}
C {iopin.sym} 3300 -227.5 0 0 {name=p620 lab=b3_p1_not}
C {iopin.sym} 2980 -167.5 2 0 {name=p621 lab=b3_c1}
C {iopin.sym} 2980 -147.5 2 0 {name=p622 lab=b3_c1_not}
C {iopin.sym} 3300 157.5 0 0 {name=p623 lab=b3_q2}
C {iopin.sym} 3300 177.5 0 0 {name=p624 lab=b3_q2_not}
C {iopin.sym} 3300 117.5 0 0 {name=p625 lab=b3_p2}
C {iopin.sym} 3300 137.5 0 0 {name=p626 lab=b3_p2_not}
C {iopin.sym} 3300 522.5 0 0 {name=p627 lab=b3_q3}
C {iopin.sym} 3300 542.5 0 0 {name=p628 lab=b3_q3_not}
C {iopin.sym} 3300 482.5 0 0 {name=p629 lab=b3_p3}
C {iopin.sym} 3300 502.5 0 0 {name=p630 lab=b3_p3_not}
C {iopin.sym} 3300 900 0 0 {name=p631 lab=b3_q4}
C {iopin.sym} 3300 920 0 0 {name=p632 lab=b3_q4_not}
C {iopin.sym} 3300 860 0 0 {name=p633 lab=b3_p4}
C {iopin.sym} 3300 880 0 0 {name=p634 lab=b3_p4_not}
C {iopin.sym} 3300 1265 0 0 {name=p635 lab=b3_q5}
C {iopin.sym} 3300 1285 0 0 {name=p636 lab=b3_q5_not}
C {iopin.sym} 3300 1225 0 0 {name=p637 lab=b3_p5}
C {iopin.sym} 3300 1245 0 0 {name=p638 lab=b3_p5_not}
C {iopin.sym} 3300 1630 0 0 {name=p639 lab=b3_q6}
C {iopin.sym} 3300 1650 0 0 {name=p640 lab=b3_q6_not}
C {iopin.sym} 3300 1590 0 0 {name=p641 lab=b3_p6}
C {iopin.sym} 3300 1610 0 0 {name=p642 lab=b3_p6_not}
C {iopin.sym} 3300 1995 0 0 {name=p643 lab=b3_q7}
C {iopin.sym} 3300 2015 0 0 {name=p644 lab=b3_q7_not}
C {iopin.sym} 3300 1955 0 0 {name=p645 lab=b3_p7}
C {iopin.sym} 3300 1975 0 0 {name=p646 lab=b3_p7_not}
C {iopin.sym} 2980 562.5 2 0 {name=p647 lab=b3_c3}
C {iopin.sym} 2980 582.5 2 0 {name=p648 lab=b3_c3_not}
C {iopin.sym} 2980 940 2 0 {name=p649 lab=b3_c4}
C {iopin.sym} 2980 960 2 0 {name=p650 lab=b3_c4_not}
C {iopin.sym} 2980 1305 2 0 {name=p651 lab=b3_c5}
C {iopin.sym} 2980 1325 2 0 {name=p652 lab=b3_c5_not}
C {iopin.sym} 2980 1670 2 0 {name=p653 lab=b3_c6}
C {iopin.sym} 2980 1690 2 0 {name=p654 lab=b3_c6_not}
C {iopin.sym} 2980 2035 2 0 {name=p655 lab=b3_c7}
C {iopin.sym} 2980 2055 2 0 {name=p656 lab=b3_c7_not}
C {lab_wire.sym} 3875 -707.5 0 0 {name=p657 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 3875 102.5 0 0 {name=p658 sig_type=std_logic lab=vss}
C {lab_wire.sym} 3715 -597.5 0 0 {name=p659 sig_type=std_logic lab=b3_r0}
C {lab_wire.sym} 3715 -577.5 0 0 {name=p660 sig_type=std_logic lab=b3_r0_not}
C {lab_wire.sym} 3715 -637.5 0 0 {name=p661 sig_type=std_logic lab=x1_s1}
C {lab_wire.sym} 3715 -617.5 0 0 {name=p662 sig_type=std_logic lab=x1_s1_not}
C {iopin.sym} 3705 -677.5 2 0 {name=p663 lab=x2_c0_f}
C {iopin.sym} 3705 -657.5 2 0 {name=p664 lab=x2_c0_f_not}
C {lab_wire.sym} 3715 -517.5 0 0 {name=p665 sig_type=std_logic lab=b3_r1}
C {lab_wire.sym} 3715 -497.5 0 0 {name=p666 sig_type=std_logic lab=b3_r1_not}
C {lab_wire.sym} 3715 -557.5 0 0 {name=p667 sig_type=std_logic lab=x1_s2}
C {lab_wire.sym} 3715 -537.5 0 0 {name=p668 sig_type=std_logic lab=x1_s2_not}
C {lab_wire.sym} 3715 -437.5 0 0 {name=p669 sig_type=std_logic lab=b3_r2}
C {lab_wire.sym} 3715 -417.5 0 0 {name=p670 sig_type=std_logic lab=b3_r2_not}
C {lab_wire.sym} 3715 -477.5 0 0 {name=p671 sig_type=std_logic lab=x1_s3}
C {lab_wire.sym} 3715 -457.5 0 0 {name=p672 sig_type=std_logic lab=x1_s3_not}
C {lab_wire.sym} 3715 -357.5 0 0 {name=p673 sig_type=std_logic lab=b3_r3}
C {lab_wire.sym} 3715 -337.5 0 0 {name=p674 sig_type=std_logic lab=b3_r3_not}
C {lab_wire.sym} 3715 -397.5 0 0 {name=p675 sig_type=std_logic lab=x1_s4}
C {lab_wire.sym} 3715 -377.5 0 0 {name=p676 sig_type=std_logic lab=x1_s4_not}
C {lab_wire.sym} 3715 -277.5 0 0 {name=p677 sig_type=std_logic lab=b3_r4}
C {lab_wire.sym} 3715 -257.5 0 0 {name=p678 sig_type=std_logic lab=b3_r4_not}
C {lab_wire.sym} 3715 -317.5 0 0 {name=p679 sig_type=std_logic lab=x1_s5}
C {lab_wire.sym} 3715 -297.5 0 0 {name=p680 sig_type=std_logic lab=x1_s5_not}
C {lab_wire.sym} 3715 -197.5 0 0 {name=p681 sig_type=std_logic lab=b3_r5}
C {lab_wire.sym} 3715 -177.5 0 0 {name=p682 sig_type=std_logic lab=b3_r5_not}
C {lab_wire.sym} 3715 -237.5 0 0 {name=p683 sig_type=std_logic lab=x1_s6}
C {lab_wire.sym} 3715 -217.5 0 0 {name=p684 sig_type=std_logic lab=x1_s6_not}
C {lab_wire.sym} 3715 -117.5 0 0 {name=p685 sig_type=std_logic lab=b3_r6}
C {lab_wire.sym} 3715 -97.5 0 0 {name=p686 sig_type=std_logic lab=b3_r6_not}
C {lab_wire.sym} 3715 -157.5 0 0 {name=p687 sig_type=std_logic lab=x1_s7}
C {lab_wire.sym} 3715 -137.5 0 0 {name=p688 sig_type=std_logic lab=x1_s7_not}
C {lab_wire.sym} 3715 -37.5 0 0 {name=p689 sig_type=std_logic lab=b3_r7}
C {lab_wire.sym} 3715 -17.5 0 0 {name=p690 sig_type=std_logic lab=b3_r7_not}
C {lab_wire.sym} 3715 -77.5 0 0 {name=p691 sig_type=std_logic lab=x1_s8}
C {lab_wire.sym} 3715 -57.5 0 0 {name=p692 sig_type=std_logic lab=x1_s8_not}
C {final_project/devices/8b_FA_ripple/8b_FA_ripple.sym} 3875 -47.5 0 0 {name=x35}
C {symbols/nfet_03v3.sym} 4167.5 102.5 0 0 {name=M17
L=0.55u
W=1.37u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4457.5 102.5 2 0 {name=M18
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {iopin.sym} 4097.5 282.5 2 0 {name=p693 lab=x2_b0_f}
C {lab_wire.sym} 4237.5 102.5 2 0 {name=p694 sig_type=std_logic lab=vss}
C {lab_wire.sym} 4387.5 102.5 0 0 {name=p695 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 4167.5 222.5 0 0 {name=M19
L=0.55u
W=1.415u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4457.5 222.5 2 0 {name=M20
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4237.5 222.5 2 0 {name=p696 sig_type=std_logic lab=vss}
C {lab_wire.sym} 4387.5 222.5 0 0 {name=p697 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 4167.5 342.5 0 0 {name=M21
L=0.55u
W=1.365u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4457.5 342.5 2 0 {name=M22
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4237.5 342.5 2 0 {name=p698 sig_type=std_logic lab=vss}
C {lab_wire.sym} 4387.5 342.5 0 0 {name=p699 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 4167.5 462.5 0 0 {name=M23
L=0.55u
W=1.385u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4457.5 462.5 2 0 {name=M24
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4237.5 462.5 2 0 {name=p700 sig_type=std_logic lab=vss}
C {lab_wire.sym} 4387.5 462.5 0 0 {name=p701 sig_type=std_logic lab=vdd}
C {iopin.sym} 4097.5 522.5 2 0 {name=p702 lab=x2_b0_f_not
}
C {lab_wire.sym} 4537.5 142.5 0 0 {name=p703 sig_type=std_logic lab=x2_s8}
C {lab_wire.sym} 4537.5 382.5 0 0 {name=p704 sig_type=std_logic lab=x2_s8_not}
C {iopin.sym} 4035 -637.5 0 0 {name=p705 lab=p3}
C {iopin.sym} 4035 -617.5 0 0 {name=p706 lab=p3_not}
C {iopin.sym} 4035 -677.5 0 0 {name=p707 lab=x2_c0_b}
C {iopin.sym} 4035 -657.5 0 0 {name=p708 lab=x2_c0_b_not}
C {iopin.sym} 4035 -597.5 0 0 {name=p709 lab=b3_r0_b}
C {iopin.sym} 4035 -577.5 0 0 {name=p710 lab=b3_r0_b_not}
C {lab_wire.sym} 4035 -557.5 0 0 {name=p711 sig_type=std_logic lab=x2_s1}
C {lab_wire.sym} 4035 -537.5 0 0 {name=p712 sig_type=std_logic lab=x2_s1_not}
C {lab_wire.sym} 4035 -477.5 0 0 {name=p713 sig_type=std_logic lab=x2_s2}
C {lab_wire.sym} 4035 -457.5 0 0 {name=p714 sig_type=std_logic lab=x2_s2_not}
C {iopin.sym} 4035 -517.5 0 0 {name=p715 lab=b3_r1_b}
C {iopin.sym} 4035 -497.5 0 0 {name=p716 lab=b3_r1_b_not}
C {iopin.sym} 4035 -437.5 0 0 {name=p717 lab=b3_r2_b}
C {iopin.sym} 4035 -417.5 0 0 {name=p718 lab=b3_r2_b_not}
C {iopin.sym} 4035 -357.5 0 0 {name=p719 lab=b3_r3_b}
C {iopin.sym} 4035 -337.5 0 0 {name=p720 lab=b3_r3_b_not}
C {iopin.sym} 4035 -277.5 0 0 {name=p721 lab=b3_r4_b}
C {iopin.sym} 4035 -257.5 0 0 {name=p722 lab=b3_r4_b_not}
C {iopin.sym} 4035 -197.5 0 0 {name=p723 lab=b3_r5_b}
C {iopin.sym} 4035 -177.5 0 0 {name=p724 lab=b3_r5_b_not}
C {iopin.sym} 4035 -117.5 0 0 {name=p725 lab=b3_r6_b}
C {iopin.sym} 4035 -97.5 0 0 {name=p726 lab=b3_r6_b_not}
C {iopin.sym} 4035 -37.5 0 0 {name=p727 lab=b3_r7_b}
C {iopin.sym} 4035 -17.5 0 0 {name=p728 lab=b3_r7_b_not}
C {lab_wire.sym} 4035 -397.5 0 0 {name=p729 sig_type=std_logic lab=x2_s3}
C {lab_wire.sym} 4035 -377.5 0 0 {name=p730 sig_type=std_logic lab=x2_s3_not}
C {lab_wire.sym} 4035 -317.5 0 0 {name=p731 sig_type=std_logic lab=x2_s4}
C {lab_wire.sym} 4035 -297.5 0 0 {name=p732 sig_type=std_logic lab=x2_s4_not}
C {lab_wire.sym} 4035 -237.5 0 0 {name=p733 sig_type=std_logic lab=x2_s5}
C {lab_wire.sym} 4035 -217.5 0 0 {name=p734 sig_type=std_logic lab=x2_s5_not}
C {lab_wire.sym} 4035 -157.5 0 0 {name=p735 sig_type=std_logic lab=x2_s6}
C {lab_wire.sym} 4035 -137.5 0 0 {name=p736 sig_type=std_logic lab=x2_s6_not}
C {lab_wire.sym} 4035 -77.5 0 0 {name=p737 sig_type=std_logic lab=x2_s7}
C {lab_wire.sym} 4035 -57.5 0 0 {name=p738 sig_type=std_logic lab=x2_s7_not}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 5002.5 -587.5 0 0 {name=x36}
C {lab_wire.sym} 5002.5 -757.5 0 0 {name=p739 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4842.5 -617.5 0 0 {name=p740 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} 4842.5 -637.5 0 0 {name=p741 sig_type=std_logic lab=a0}
C {lab_wire.sym} 4842.5 -577.5 0 0 {name=p742 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} 4842.5 -597.5 0 0 {name=p743 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4992.5 -427.5 0 0 {name=p744 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 5002.5 -222.5 0 0 {name=x37}
C {lab_wire.sym} 5002.5 -392.5 0 0 {name=p745 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4842.5 -252.5 0 0 {name=p746 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} 4842.5 -272.5 0 0 {name=p747 sig_type=std_logic lab=a1}
C {lab_wire.sym} 4842.5 -212.5 0 0 {name=p748 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} 4842.5 -232.5 0 0 {name=p749 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4992.5 -62.5 0 0 {name=p750 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 5002.5 142.5 0 0 {name=x38}
C {lab_wire.sym} 5002.5 -27.5 0 0 {name=p751 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4842.5 112.5 0 0 {name=p754 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} 4842.5 92.5 0 0 {name=p755 sig_type=std_logic lab=a2}
C {lab_wire.sym} 4842.5 152.5 0 0 {name=p756 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} 4842.5 132.5 0 0 {name=p757 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4992.5 302.5 0 0 {name=p758 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 5002.5 507.5 0 0 {name=x39}
C {lab_wire.sym} 5002.5 337.5 0 0 {name=p759 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4842.5 477.5 0 0 {name=p760 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} 4842.5 457.5 0 0 {name=p761 sig_type=std_logic lab=a3}
C {lab_wire.sym} 4842.5 517.5 0 0 {name=p762 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} 4842.5 497.5 0 0 {name=p763 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4992.5 667.5 0 0 {name=p764 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 5002.5 885 0 0 {name=x40}
C {lab_wire.sym} 5002.5 715 0 0 {name=p765 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4842.5 855 0 0 {name=p766 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} 4842.5 835 0 0 {name=p767 sig_type=std_logic lab=a4}
C {lab_wire.sym} 4842.5 895 0 0 {name=p768 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} 4842.5 875 0 0 {name=p769 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4992.5 1045 0 0 {name=p770 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 5002.5 1250 0 0 {name=x41}
C {lab_wire.sym} 5002.5 1080 0 0 {name=p771 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4842.5 1220 0 0 {name=p772 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} 4842.5 1200 0 0 {name=p773 sig_type=std_logic lab=a5}
C {lab_wire.sym} 4842.5 1260 0 0 {name=p774 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} 4842.5 1240 0 0 {name=p775 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4992.5 1410 0 0 {name=p776 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 5002.5 1615 0 0 {name=x42}
C {lab_wire.sym} 5002.5 1445 0 0 {name=p777 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4842.5 1585 0 0 {name=p778 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} 4842.5 1565 0 0 {name=p779 sig_type=std_logic lab=a6}
C {lab_wire.sym} 4842.5 1625 0 0 {name=p780 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} 4842.5 1605 0 0 {name=p781 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4992.5 1775 0 0 {name=p782 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 5002.5 1980 0 0 {name=x43}
C {lab_wire.sym} 5002.5 1810 0 0 {name=p783 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 4842.5 1950 0 0 {name=p784 sig_type=std_logic lab=a7_not}
C {lab_wire.sym} 4842.5 1930 0 0 {name=p785 sig_type=std_logic lab=a7}
C {lab_wire.sym} 4842.5 1990 0 0 {name=p786 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} 4842.5 1970 0 0 {name=p787 sig_type=std_logic lab=b4}
C {lab_wire.sym} 4992.5 2140 0 0 {name=p788 sig_type=std_logic lab=vss}
C {lab_wire.sym} 5162.5 -557.5 0 0 {name=p789 sig_type=std_logic lab=b4_r0}
C {lab_wire.sym} 5162.5 -537.5 0 0 {name=p790 sig_type=std_logic lab=b4_r0_not}
C {lab_wire.sym} 5162.5 -192.5 0 0 {name=p791 sig_type=std_logic lab=b4_r1}
C {lab_wire.sym} 5162.5 -172.5 0 0 {name=p792 sig_type=std_logic lab=b4_r1_not}
C {lab_wire.sym} 5162.5 172.5 0 0 {name=p793 sig_type=std_logic lab=b4_r2}
C {lab_wire.sym} 5162.5 192.5 0 0 {name=p794 sig_type=std_logic lab=b4_r2_not}
C {lab_wire.sym} 5162.5 537.5 0 0 {name=p795 sig_type=std_logic lab=b4_r3}
C {lab_wire.sym} 5162.5 557.5 0 0 {name=p796 sig_type=std_logic lab=b4_r3_not}
C {lab_wire.sym} 5162.5 915 0 0 {name=p797 sig_type=std_logic lab=b4_r4}
C {lab_wire.sym} 5162.5 935 0 0 {name=p798 sig_type=std_logic lab=b4_r4_not}
C {lab_wire.sym} 5162.5 1280 0 0 {name=p799 sig_type=std_logic lab=b4_r5}
C {lab_wire.sym} 5162.5 1300 0 0 {name=p800 sig_type=std_logic lab=b4_r5_not}
C {lab_wire.sym} 5162.5 1645 0 0 {name=p801 sig_type=std_logic lab=b4_r6}
C {lab_wire.sym} 5162.5 1665 0 0 {name=p802 sig_type=std_logic lab=b4_r6_not}
C {lab_wire.sym} 5162.5 2010 0 0 {name=p803 sig_type=std_logic lab=b4_r7}
C {lab_wire.sym} 5162.5 2030 0 0 {name=p804 sig_type=std_logic lab=b4_r7_not}
C {iopin.sym} 4842.5 -557.5 2 0 {name=p805 lab=b4_c0}
C {iopin.sym} 4842.5 -537.5 2 0 {name=p806 lab=b4_c0_not}
C {iopin.sym} 5162.5 -597.5 0 0 {name=p807 lab=b4_q0}
C {iopin.sym} 5162.5 -577.5 0 0 {name=p808 lab=b4_q0_not}
C {iopin.sym} 5162.5 -637.5 0 0 {name=p809 lab=b4_p0}
C {iopin.sym} 5162.5 -617.5 0 0 {name=p810 lab=b4_p0_not}
C {iopin.sym} 5162.5 -232.5 0 0 {name=p811 lab=b4_q1}
C {iopin.sym} 5162.5 -212.5 0 0 {name=p812 lab=b4_q1_not}
C {iopin.sym} 5162.5 -272.5 0 0 {name=p813 lab=b4_p1}
C {iopin.sym} 5162.5 -252.5 0 0 {name=p814 lab=b4_p1_not}
C {iopin.sym} 4842.5 -192.5 2 0 {name=p815 lab=b4_c1}
C {iopin.sym} 4842.5 -172.5 2 0 {name=p816 lab=b4_c1_not}
C {iopin.sym} 5162.5 132.5 0 0 {name=p817 lab=b4_q2}
C {iopin.sym} 5162.5 152.5 0 0 {name=p818 lab=b4_q2_not}
C {iopin.sym} 5162.5 92.5 0 0 {name=p819 lab=b4_p2}
C {iopin.sym} 5162.5 112.5 0 0 {name=p820 lab=b4_p2_not}
C {iopin.sym} 5162.5 497.5 0 0 {name=p821 lab=b4_q3}
C {iopin.sym} 5162.5 517.5 0 0 {name=p822 lab=b4_q3_not}
C {iopin.sym} 5162.5 457.5 0 0 {name=p823 lab=b4_p3}
C {iopin.sym} 5162.5 477.5 0 0 {name=p824 lab=b4_p3_not}
C {iopin.sym} 5162.5 875 0 0 {name=p825 lab=b4_q4}
C {iopin.sym} 5162.5 895 0 0 {name=p826 lab=b4_q4_not}
C {iopin.sym} 5162.5 835 0 0 {name=p827 lab=b4_p4}
C {iopin.sym} 5162.5 855 0 0 {name=p828 lab=b4_p4_not}
C {iopin.sym} 5162.5 1240 0 0 {name=p829 lab=b4_q5}
C {iopin.sym} 5162.5 1260 0 0 {name=p830 lab=b4_q5_not}
C {iopin.sym} 5162.5 1200 0 0 {name=p831 lab=b4_p5}
C {iopin.sym} 5162.5 1220 0 0 {name=p832 lab=b4_p5_not}
C {iopin.sym} 5162.5 1605 0 0 {name=p833 lab=b4_q6}
C {iopin.sym} 5162.5 1625 0 0 {name=p834 lab=b4_q6_not}
C {iopin.sym} 5162.5 1565 0 0 {name=p835 lab=b4_p6}
C {iopin.sym} 5162.5 1585 0 0 {name=p836 lab=b4_p6_not}
C {iopin.sym} 5162.5 1970 0 0 {name=p837 lab=b4_q7}
C {iopin.sym} 5162.5 1990 0 0 {name=p838 lab=b4_q7_not}
C {iopin.sym} 5162.5 1930 0 0 {name=p839 lab=b4_p7}
C {iopin.sym} 5162.5 1950 0 0 {name=p840 lab=b4_p7_not}
C {iopin.sym} 4842.5 537.5 2 0 {name=p841 lab=b4_c3}
C {iopin.sym} 4842.5 557.5 2 0 {name=p842 lab=b4_c3_not}
C {iopin.sym} 4842.5 915 2 0 {name=p843 lab=b4_c4}
C {iopin.sym} 4842.5 935 2 0 {name=p844 lab=b4_c4_not}
C {iopin.sym} 4842.5 1280 2 0 {name=p845 lab=b4_c5}
C {iopin.sym} 4842.5 1300 2 0 {name=p846 lab=b4_c5_not}
C {iopin.sym} 4842.5 1645 2 0 {name=p847 lab=b4_c6}
C {iopin.sym} 4842.5 1665 2 0 {name=p848 lab=b4_c6_not}
C {iopin.sym} 4842.5 2010 2 0 {name=p849 lab=b4_c7}
C {iopin.sym} 4842.5 2030 2 0 {name=p850 lab=b4_c7_not}
C {lab_wire.sym} 5732.5 -737.5 0 0 {name=p851 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 5732.5 72.5 0 0 {name=p852 sig_type=std_logic lab=vss}
C {lab_wire.sym} 5572.5 -627.5 0 0 {name=p853 sig_type=std_logic lab=b4_r0}
C {lab_wire.sym} 5572.5 -607.5 0 0 {name=p854 sig_type=std_logic lab=b4_r0_not}
C {lab_wire.sym} 5572.5 -667.5 0 0 {name=p855 sig_type=std_logic lab=x2_s1}
C {lab_wire.sym} 5572.5 -647.5 0 0 {name=p856 sig_type=std_logic lab=x2_s1_not}
C {iopin.sym} 5562.5 -707.5 2 0 {name=p857 lab=x3_c0_f}
C {iopin.sym} 5562.5 -687.5 2 0 {name=p858 lab=x3_c0_f_not}
C {lab_wire.sym} 5572.5 -547.5 0 0 {name=p859 sig_type=std_logic lab=b4_r1}
C {lab_wire.sym} 5572.5 -527.5 0 0 {name=p860 sig_type=std_logic lab=b4_r1_not}
C {lab_wire.sym} 5572.5 -587.5 0 0 {name=p861 sig_type=std_logic lab=x2_s2}
C {lab_wire.sym} 5572.5 -567.5 0 0 {name=p862 sig_type=std_logic lab=x2_s2_not}
C {lab_wire.sym} 5572.5 -467.5 0 0 {name=p863 sig_type=std_logic lab=b4_r2}
C {lab_wire.sym} 5572.5 -447.5 0 0 {name=p864 sig_type=std_logic lab=b4_r2_not}
C {lab_wire.sym} 5572.5 -507.5 0 0 {name=p865 sig_type=std_logic lab=x2_s3}
C {lab_wire.sym} 5572.5 -487.5 0 0 {name=p866 sig_type=std_logic lab=x2_s3_not}
C {lab_wire.sym} 5572.5 -387.5 0 0 {name=p867 sig_type=std_logic lab=b4_r3}
C {lab_wire.sym} 5572.5 -367.5 0 0 {name=p868 sig_type=std_logic lab=b4_r3_not}
C {lab_wire.sym} 5572.5 -427.5 0 0 {name=p869 sig_type=std_logic lab=x2_s4}
C {lab_wire.sym} 5572.5 -407.5 0 0 {name=p870 sig_type=std_logic lab=x2_s4_not}
C {lab_wire.sym} 5572.5 -307.5 0 0 {name=p871 sig_type=std_logic lab=b4_r4}
C {lab_wire.sym} 5572.5 -287.5 0 0 {name=p872 sig_type=std_logic lab=b4_r4_not}
C {lab_wire.sym} 5572.5 -347.5 0 0 {name=p873 sig_type=std_logic lab=x2_s5}
C {lab_wire.sym} 5572.5 -327.5 0 0 {name=p874 sig_type=std_logic lab=x2_s5_not}
C {lab_wire.sym} 5572.5 -227.5 0 0 {name=p875 sig_type=std_logic lab=b4_r5}
C {lab_wire.sym} 5572.5 -207.5 0 0 {name=p876 sig_type=std_logic lab=b4_r5_not}
C {lab_wire.sym} 5572.5 -267.5 0 0 {name=p877 sig_type=std_logic lab=x2_s6}
C {lab_wire.sym} 5572.5 -247.5 0 0 {name=p878 sig_type=std_logic lab=x2_s6_not}
C {lab_wire.sym} 5572.5 -147.5 0 0 {name=p879 sig_type=std_logic lab=b4_r6}
C {lab_wire.sym} 5572.5 -127.5 0 0 {name=p880 sig_type=std_logic lab=b4_r6_not}
C {lab_wire.sym} 5572.5 -187.5 0 0 {name=p881 sig_type=std_logic lab=x2_s7}
C {lab_wire.sym} 5572.5 -167.5 0 0 {name=p882 sig_type=std_logic lab=x2_s7_not}
C {lab_wire.sym} 5572.5 -67.5 0 0 {name=p883 sig_type=std_logic lab=b4_r7}
C {lab_wire.sym} 5572.5 -47.5 0 0 {name=p884 sig_type=std_logic lab=b4_r7_not}
C {lab_wire.sym} 5572.5 -107.5 0 0 {name=p885 sig_type=std_logic lab=x2_s8}
C {lab_wire.sym} 5572.5 -87.5 0 0 {name=p886 sig_type=std_logic lab=x2_s8_not}
C {final_project/devices/8b_FA_ripple/8b_FA_ripple.sym} 5732.5 -77.5 0 0 {name=x44}
C {symbols/nfet_03v3.sym} 6025 72.5 0 0 {name=M25
L=0.55u
W=1.37u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6315 72.5 2 0 {name=M26
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {iopin.sym} 5955 252.5 2 0 {name=p887 lab=x3_b0_f}
C {lab_wire.sym} 6095 72.5 2 0 {name=p888 sig_type=std_logic lab=vss}
C {lab_wire.sym} 6245 72.5 0 0 {name=p889 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 6025 192.5 0 0 {name=M27
L=0.55u
W=1.415u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6315 192.5 2 0 {name=M28
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 6095 192.5 2 0 {name=p890 sig_type=std_logic lab=vss}
C {lab_wire.sym} 6245 192.5 0 0 {name=p891 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 6025 312.5 0 0 {name=M29
L=0.55u
W=1.365u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6315 312.5 2 0 {name=M30
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 6095 312.5 2 0 {name=p892 sig_type=std_logic lab=vss}
C {lab_wire.sym} 6245 312.5 0 0 {name=p893 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 6025 432.5 0 0 {name=M31
L=0.55u
W=1.385u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6315 432.5 2 0 {name=M32
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 6095 432.5 2 0 {name=p894 sig_type=std_logic lab=vss}
C {lab_wire.sym} 6245 432.5 0 0 {name=p895 sig_type=std_logic lab=vdd}
C {iopin.sym} 5955 492.5 2 0 {name=p896 lab=x3_b0_f_not
}
C {lab_wire.sym} 6395 112.5 0 0 {name=p897 sig_type=std_logic lab=x3_s8}
C {lab_wire.sym} 6395 352.5 0 0 {name=p898 sig_type=std_logic lab=x3_s8_not}
C {iopin.sym} 5892.5 -667.5 0 0 {name=p899 lab=p4}
C {iopin.sym} 5892.5 -647.5 0 0 {name=p900 lab=p4_not}
C {iopin.sym} 5892.5 -707.5 0 0 {name=p901 lab=x3_c0_b}
C {iopin.sym} 5892.5 -687.5 0 0 {name=p902 lab=x3_c0_b_not}
C {iopin.sym} 5892.5 -627.5 0 0 {name=p903 lab=b4_r0_b}
C {iopin.sym} 5892.5 -607.5 0 0 {name=p904 lab=b4_r0_b_not}
C {lab_wire.sym} 5892.5 -587.5 0 0 {name=p905 sig_type=std_logic lab=x3_s1}
C {lab_wire.sym} 5892.5 -567.5 0 0 {name=p906 sig_type=std_logic lab=x3_s1_not}
C {lab_wire.sym} 5892.5 -507.5 0 0 {name=p907 sig_type=std_logic lab=x3_s2}
C {lab_wire.sym} 5892.5 -487.5 0 0 {name=p908 sig_type=std_logic lab=x3_s2_not}
C {iopin.sym} 5892.5 -547.5 0 0 {name=p909 lab=b4_r1_b}
C {iopin.sym} 5892.5 -527.5 0 0 {name=p910 lab=b4_r1_b_not}
C {iopin.sym} 5892.5 -467.5 0 0 {name=p911 lab=b4_r2_b}
C {iopin.sym} 5892.5 -447.5 0 0 {name=p912 lab=b4_r2_b_not}
C {iopin.sym} 5892.5 -387.5 0 0 {name=p913 lab=b4_r3_b}
C {iopin.sym} 5892.5 -367.5 0 0 {name=p914 lab=b4_r3_b_not}
C {iopin.sym} 5892.5 -307.5 0 0 {name=p915 lab=b4_r4_b}
C {iopin.sym} 5892.5 -287.5 0 0 {name=p916 lab=b4_r4_b_not}
C {iopin.sym} 5892.5 -227.5 0 0 {name=p917 lab=b4_r5_b}
C {iopin.sym} 5892.5 -207.5 0 0 {name=p918 lab=b4_r5_b_not}
C {iopin.sym} 5892.5 -147.5 0 0 {name=p919 lab=b4_r6_b}
C {iopin.sym} 5892.5 -127.5 0 0 {name=p920 lab=b4_r6_b_not}
C {iopin.sym} 5892.5 -67.5 0 0 {name=p921 lab=b4_r7_b}
C {iopin.sym} 5892.5 -47.5 0 0 {name=p922 lab=b4_r7_b_not}
C {lab_wire.sym} 5892.5 -427.5 0 0 {name=p923 sig_type=std_logic lab=x3_s3}
C {lab_wire.sym} 5892.5 -407.5 0 0 {name=p924 sig_type=std_logic lab=x3_s3_not}
C {lab_wire.sym} 5892.5 -347.5 0 0 {name=p925 sig_type=std_logic lab=x3_s4}
C {lab_wire.sym} 5892.5 -327.5 0 0 {name=p926 sig_type=std_logic lab=x3_s4_not}
C {lab_wire.sym} 5892.5 -267.5 0 0 {name=p927 sig_type=std_logic lab=x3_s5}
C {lab_wire.sym} 5892.5 -247.5 0 0 {name=p928 sig_type=std_logic lab=x3_s5_not}
C {lab_wire.sym} 5892.5 -187.5 0 0 {name=p929 sig_type=std_logic lab=x3_s6}
C {lab_wire.sym} 5892.5 -167.5 0 0 {name=p930 sig_type=std_logic lab=x3_s6_not}
C {lab_wire.sym} 5892.5 -107.5 0 0 {name=p931 sig_type=std_logic lab=x3_s7}
C {lab_wire.sym} 5892.5 -87.5 0 0 {name=p932 sig_type=std_logic lab=x3_s7_not}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 6902.5 -577.5 0 0 {name=x45}
C {lab_wire.sym} 6902.5 -747.5 0 0 {name=p933 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 6742.5 -607.5 0 0 {name=p934 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} 6742.5 -627.5 0 0 {name=p935 sig_type=std_logic lab=a0}
C {lab_wire.sym} 6742.5 -567.5 0 0 {name=p936 sig_type=std_logic lab=b5_not}
C {lab_wire.sym} 6742.5 -587.5 0 0 {name=p937 sig_type=std_logic lab=b5}
C {lab_wire.sym} 6892.5 -417.5 0 0 {name=p938 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 6902.5 -212.5 0 0 {name=x46}
C {lab_wire.sym} 6902.5 -382.5 0 0 {name=p939 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 6742.5 -242.5 0 0 {name=p940 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} 6742.5 -262.5 0 0 {name=p941 sig_type=std_logic lab=a1}
C {lab_wire.sym} 6742.5 -202.5 0 0 {name=p942 sig_type=std_logic lab=b5_not}
C {lab_wire.sym} 6742.5 -222.5 0 0 {name=p943 sig_type=std_logic lab=b5}
C {lab_wire.sym} 6892.5 -52.5 0 0 {name=p944 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 6902.5 152.5 0 0 {name=x47}
C {lab_wire.sym} 6902.5 -17.5 0 0 {name=p945 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 6742.5 122.5 0 0 {name=p948 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} 6742.5 102.5 0 0 {name=p949 sig_type=std_logic lab=a2}
C {lab_wire.sym} 6742.5 162.5 0 0 {name=p950 sig_type=std_logic lab=b5_not}
C {lab_wire.sym} 6742.5 142.5 0 0 {name=p951 sig_type=std_logic lab=b5}
C {lab_wire.sym} 6892.5 312.5 0 0 {name=p952 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 6902.5 517.5 0 0 {name=x48}
C {lab_wire.sym} 6902.5 347.5 0 0 {name=p953 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 6742.5 487.5 0 0 {name=p954 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} 6742.5 467.5 0 0 {name=p955 sig_type=std_logic lab=a3}
C {lab_wire.sym} 6742.5 527.5 0 0 {name=p956 sig_type=std_logic lab=b5_not}
C {lab_wire.sym} 6742.5 507.5 0 0 {name=p957 sig_type=std_logic lab=b5}
C {lab_wire.sym} 6892.5 677.5 0 0 {name=p958 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 6902.5 895 0 0 {name=x49}
C {lab_wire.sym} 6902.5 725 0 0 {name=p959 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 6742.5 865 0 0 {name=p960 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} 6742.5 845 0 0 {name=p961 sig_type=std_logic lab=a4}
C {lab_wire.sym} 6742.5 905 0 0 {name=p962 sig_type=std_logic lab=b5_not}
C {lab_wire.sym} 6742.5 885 0 0 {name=p963 sig_type=std_logic lab=b5}
C {lab_wire.sym} 6892.5 1055 0 0 {name=p964 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 6902.5 1260 0 0 {name=x50}
C {lab_wire.sym} 6902.5 1090 0 0 {name=p965 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 6742.5 1230 0 0 {name=p966 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} 6742.5 1210 0 0 {name=p967 sig_type=std_logic lab=a5}
C {lab_wire.sym} 6742.5 1270 0 0 {name=p968 sig_type=std_logic lab=b5_not}
C {lab_wire.sym} 6742.5 1250 0 0 {name=p969 sig_type=std_logic lab=b5}
C {lab_wire.sym} 6892.5 1420 0 0 {name=p970 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 6902.5 1625 0 0 {name=x51}
C {lab_wire.sym} 6902.5 1455 0 0 {name=p971 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 6742.5 1595 0 0 {name=p972 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} 6742.5 1575 0 0 {name=p973 sig_type=std_logic lab=a6}
C {lab_wire.sym} 6742.5 1635 0 0 {name=p974 sig_type=std_logic lab=b5_not}
C {lab_wire.sym} 6742.5 1615 0 0 {name=p975 sig_type=std_logic lab=b5}
C {lab_wire.sym} 6892.5 1785 0 0 {name=p976 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 6902.5 1990 0 0 {name=x52}
C {lab_wire.sym} 6902.5 1820 0 0 {name=p977 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 6742.5 1960 0 0 {name=p978 sig_type=std_logic lab=a7_not}
C {lab_wire.sym} 6742.5 1940 0 0 {name=p979 sig_type=std_logic lab=a7}
C {lab_wire.sym} 6742.5 2000 0 0 {name=p980 sig_type=std_logic lab=b5_not}
C {lab_wire.sym} 6742.5 1980 0 0 {name=p981 sig_type=std_logic lab=b5}
C {lab_wire.sym} 6892.5 2150 0 0 {name=p982 sig_type=std_logic lab=vss}
C {lab_wire.sym} 7062.5 -547.5 0 0 {name=p983 sig_type=std_logic lab=b5_r0}
C {lab_wire.sym} 7062.5 -527.5 0 0 {name=p984 sig_type=std_logic lab=b5_r0_not}
C {lab_wire.sym} 7062.5 -182.5 0 0 {name=p985 sig_type=std_logic lab=b5_r1}
C {lab_wire.sym} 7062.5 -162.5 0 0 {name=p986 sig_type=std_logic lab=b5_r1_not}
C {lab_wire.sym} 7062.5 182.5 0 0 {name=p987 sig_type=std_logic lab=b5_r2}
C {lab_wire.sym} 7062.5 202.5 0 0 {name=p988 sig_type=std_logic lab=b5_r2_not}
C {lab_wire.sym} 7062.5 547.5 0 0 {name=p989 sig_type=std_logic lab=b5_r3}
C {lab_wire.sym} 7062.5 567.5 0 0 {name=p990 sig_type=std_logic lab=b5_r3_not}
C {lab_wire.sym} 7062.5 925 0 0 {name=p991 sig_type=std_logic lab=b5_r4}
C {lab_wire.sym} 7062.5 945 0 0 {name=p992 sig_type=std_logic lab=b5_r4_not}
C {lab_wire.sym} 7062.5 1290 0 0 {name=p993 sig_type=std_logic lab=b5_r5}
C {lab_wire.sym} 7062.5 1310 0 0 {name=p994 sig_type=std_logic lab=b5_r5_not}
C {lab_wire.sym} 7062.5 1655 0 0 {name=p995 sig_type=std_logic lab=b5_r6}
C {lab_wire.sym} 7062.5 1675 0 0 {name=p996 sig_type=std_logic lab=b5_r6_not}
C {lab_wire.sym} 7062.5 2020 0 0 {name=p997 sig_type=std_logic lab=b5_r7}
C {lab_wire.sym} 7062.5 2040 0 0 {name=p998 sig_type=std_logic lab=b5_r7_not}
C {iopin.sym} 6742.5 -547.5 2 0 {name=p999 lab=b5_c0}
C {iopin.sym} 6742.5 -527.5 2 0 {name=p1000 lab=b5_c0_not}
C {iopin.sym} 7062.5 -587.5 0 0 {name=p1001 lab=b5_q0}
C {iopin.sym} 7062.5 -567.5 0 0 {name=p1002 lab=b5_q0_not}
C {iopin.sym} 7062.5 -627.5 0 0 {name=p1003 lab=b5_p0}
C {iopin.sym} 7062.5 -607.5 0 0 {name=p1004 lab=b5_p0_not}
C {iopin.sym} 7062.5 -222.5 0 0 {name=p1005 lab=b5_q1}
C {iopin.sym} 7062.5 -202.5 0 0 {name=p1006 lab=b5_q1_not}
C {iopin.sym} 7062.5 -262.5 0 0 {name=p1007 lab=b5_p1}
C {iopin.sym} 7062.5 -242.5 0 0 {name=p1008 lab=b5_p1_not}
C {iopin.sym} 6742.5 -182.5 2 0 {name=p1009 lab=b5_c1}
C {iopin.sym} 6742.5 -162.5 2 0 {name=p1010 lab=b5_c1_not}
C {iopin.sym} 7062.5 142.5 0 0 {name=p1011 lab=b5_q2}
C {iopin.sym} 7062.5 162.5 0 0 {name=p1012 lab=b5_q2_not}
C {iopin.sym} 7062.5 102.5 0 0 {name=p1013 lab=b5_p2}
C {iopin.sym} 7062.5 122.5 0 0 {name=p1014 lab=b5_p2_not}
C {iopin.sym} 7062.5 507.5 0 0 {name=p1015 lab=b5_q3}
C {iopin.sym} 7062.5 527.5 0 0 {name=p1016 lab=b5_q3_not}
C {iopin.sym} 7062.5 467.5 0 0 {name=p1017 lab=b5_p3}
C {iopin.sym} 7062.5 487.5 0 0 {name=p1018 lab=b5_p3_not}
C {iopin.sym} 7062.5 885 0 0 {name=p1019 lab=b5_q4}
C {iopin.sym} 7062.5 905 0 0 {name=p1020 lab=b5_q4_not}
C {iopin.sym} 7062.5 845 0 0 {name=p1021 lab=b5_p4}
C {iopin.sym} 7062.5 865 0 0 {name=p1022 lab=b5_p4_not}
C {iopin.sym} 7062.5 1250 0 0 {name=p1023 lab=b5_q5}
C {iopin.sym} 7062.5 1270 0 0 {name=p1024 lab=b5_q5_not}
C {iopin.sym} 7062.5 1210 0 0 {name=p1025 lab=b5_p5}
C {iopin.sym} 7062.5 1230 0 0 {name=p1026 lab=b5_p5_not}
C {iopin.sym} 7062.5 1615 0 0 {name=p1027 lab=b5_q6}
C {iopin.sym} 7062.5 1635 0 0 {name=p1028 lab=b5_q6_not}
C {iopin.sym} 7062.5 1575 0 0 {name=p1029 lab=b5_p6}
C {iopin.sym} 7062.5 1595 0 0 {name=p1030 lab=b5_p6_not}
C {iopin.sym} 7062.5 1980 0 0 {name=p1031 lab=b5_q7}
C {iopin.sym} 7062.5 2000 0 0 {name=p1032 lab=b5_q7_not}
C {iopin.sym} 7062.5 1940 0 0 {name=p1033 lab=b5_p7}
C {iopin.sym} 7062.5 1960 0 0 {name=p1034 lab=b5_p7_not}
C {iopin.sym} 6742.5 547.5 2 0 {name=p1035 lab=b5_c3}
C {iopin.sym} 6742.5 567.5 2 0 {name=p1036 lab=b5_c3_not}
C {iopin.sym} 6742.5 925 2 0 {name=p1037 lab=b5_c4}
C {iopin.sym} 6742.5 945 2 0 {name=p1038 lab=b5_c4_not}
C {iopin.sym} 6742.5 1290 2 0 {name=p1039 lab=b5_c5}
C {iopin.sym} 6742.5 1310 2 0 {name=p1040 lab=b5_c5_not}
C {iopin.sym} 6742.5 1655 2 0 {name=p1041 lab=b5_c6}
C {iopin.sym} 6742.5 1675 2 0 {name=p1042 lab=b5_c6_not}
C {iopin.sym} 6742.5 2020 2 0 {name=p1043 lab=b5_c7}
C {iopin.sym} 6742.5 2040 2 0 {name=p1044 lab=b5_c7_not}
C {lab_wire.sym} 7760 -740 0 0 {name=p1045 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 7760 70 0 0 {name=p1046 sig_type=std_logic lab=vss}
C {lab_wire.sym} 7600 -630 0 0 {name=p1047 sig_type=std_logic lab=b5_r0}
C {lab_wire.sym} 7600 -610 0 0 {name=p1048 sig_type=std_logic lab=b5_r0_not}
C {lab_wire.sym} 7600 -670 0 0 {name=p1049 sig_type=std_logic lab=x3_s1}
C {lab_wire.sym} 7600 -650 0 0 {name=p1050 sig_type=std_logic lab=x3_s1_not}
C {iopin.sym} 7590 -710 2 0 {name=p1051 lab=x4_c0_f}
C {iopin.sym} 7590 -690 2 0 {name=p1052 lab=x4_c0_f_not}
C {lab_wire.sym} 7600 -550 0 0 {name=p1053 sig_type=std_logic lab=b5_r1}
C {lab_wire.sym} 7600 -530 0 0 {name=p1054 sig_type=std_logic lab=b5_r1_not}
C {lab_wire.sym} 7600 -590 0 0 {name=p1055 sig_type=std_logic lab=x3_s2}
C {lab_wire.sym} 7600 -570 0 0 {name=p1056 sig_type=std_logic lab=x3_s2_not}
C {lab_wire.sym} 7600 -470 0 0 {name=p1057 sig_type=std_logic lab=b5_r2}
C {lab_wire.sym} 7600 -450 0 0 {name=p1058 sig_type=std_logic lab=b5_r2_not}
C {lab_wire.sym} 7600 -510 0 0 {name=p1059 sig_type=std_logic lab=x3_s3}
C {lab_wire.sym} 7600 -490 0 0 {name=p1060 sig_type=std_logic lab=x3_s3_not}
C {lab_wire.sym} 7600 -390 0 0 {name=p1061 sig_type=std_logic lab=b5_r3}
C {lab_wire.sym} 7600 -370 0 0 {name=p1062 sig_type=std_logic lab=b5_r3_not}
C {lab_wire.sym} 7600 -430 0 0 {name=p1063 sig_type=std_logic lab=x3_s4}
C {lab_wire.sym} 7600 -410 0 0 {name=p1064 sig_type=std_logic lab=x3_s4_not}
C {lab_wire.sym} 7600 -310 0 0 {name=p1065 sig_type=std_logic lab=b5_r4}
C {lab_wire.sym} 7600 -290 0 0 {name=p1066 sig_type=std_logic lab=b5_r4_not}
C {lab_wire.sym} 7600 -350 0 0 {name=p1067 sig_type=std_logic lab=x3_s5}
C {lab_wire.sym} 7600 -330 0 0 {name=p1068 sig_type=std_logic lab=x3_s5_not}
C {lab_wire.sym} 7600 -230 0 0 {name=p1069 sig_type=std_logic lab=b5_r5}
C {lab_wire.sym} 7600 -210 0 0 {name=p1070 sig_type=std_logic lab=b5_r5_not}
C {lab_wire.sym} 7600 -270 0 0 {name=p1071 sig_type=std_logic lab=x3_s6}
C {lab_wire.sym} 7600 -250 0 0 {name=p1072 sig_type=std_logic lab=x3_s6_not}
C {lab_wire.sym} 7600 -150 0 0 {name=p1073 sig_type=std_logic lab=b5_r6}
C {lab_wire.sym} 7600 -130 0 0 {name=p1074 sig_type=std_logic lab=b5_r6_not}
C {lab_wire.sym} 7600 -190 0 0 {name=p1075 sig_type=std_logic lab=x3_s7}
C {lab_wire.sym} 7600 -170 0 0 {name=p1076 sig_type=std_logic lab=x3_s7_not}
C {lab_wire.sym} 7600 -70 0 0 {name=p1077 sig_type=std_logic lab=b5_r7}
C {lab_wire.sym} 7600 -50 0 0 {name=p1078 sig_type=std_logic lab=b5_r7_not}
C {lab_wire.sym} 7600 -110 0 0 {name=p1079 sig_type=std_logic lab=x3_s8}
C {lab_wire.sym} 7600 -90 0 0 {name=p1080 sig_type=std_logic lab=x3_s8_not}
C {final_project/devices/8b_FA_ripple/8b_FA_ripple.sym} 7760 -80 0 0 {name=x53}
C {symbols/nfet_03v3.sym} 8052.5 70 0 0 {name=M33
L=0.55u
W=1.37u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 8342.5 70 2 0 {name=M34
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {iopin.sym} 7982.5 250 2 0 {name=p1081 lab=x4_b0_f}
C {lab_wire.sym} 8122.5 70 2 0 {name=p1082 sig_type=std_logic lab=vss}
C {lab_wire.sym} 8272.5 70 0 0 {name=p1083 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 8052.5 190 0 0 {name=M35
L=0.55u
W=1.415u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 8342.5 190 2 0 {name=M36
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 8122.5 190 2 0 {name=p1084 sig_type=std_logic lab=vss}
C {lab_wire.sym} 8272.5 190 0 0 {name=p1085 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 8052.5 310 0 0 {name=M37
L=0.55u
W=1.365u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 8342.5 310 2 0 {name=M38
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 8122.5 310 2 0 {name=p1086 sig_type=std_logic lab=vss}
C {lab_wire.sym} 8272.5 310 0 0 {name=p1087 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 8052.5 430 0 0 {name=M39
L=0.55u
W=1.385u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 8342.5 430 2 0 {name=M40
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 8122.5 430 2 0 {name=p1088 sig_type=std_logic lab=vss}
C {lab_wire.sym} 8272.5 430 0 0 {name=p1089 sig_type=std_logic lab=vdd}
C {iopin.sym} 7982.5 490 2 0 {name=p1090 lab=x4_b0_f_not
}
C {lab_wire.sym} 8422.5 110 0 0 {name=p1091 sig_type=std_logic lab=x4_s8}
C {lab_wire.sym} 8422.5 350 0 0 {name=p1092 sig_type=std_logic lab=x4_s8_not}
C {iopin.sym} 7920 -670 0 0 {name=p1093 lab=p5}
C {iopin.sym} 7920 -650 0 0 {name=p1094 lab=p5_not}
C {iopin.sym} 7920 -710 0 0 {name=p1095 lab=x4_c0_b}
C {iopin.sym} 7920 -690 0 0 {name=p1096 lab=x4_c0_b_not}
C {iopin.sym} 7920 -630 0 0 {name=p1097 lab=b5_r0_b}
C {iopin.sym} 7920 -610 0 0 {name=p1098 lab=b5_r0_b_not}
C {lab_wire.sym} 7920 -590 0 0 {name=p1099 sig_type=std_logic lab=x4_s1}
C {lab_wire.sym} 7920 -570 0 0 {name=p1100 sig_type=std_logic lab=x4_s1_not}
C {lab_wire.sym} 7920 -510 0 0 {name=p1101 sig_type=std_logic lab=x4_s2}
C {lab_wire.sym} 7920 -490 0 0 {name=p1102 sig_type=std_logic lab=x4_s2_not}
C {iopin.sym} 7920 -550 0 0 {name=p1103 lab=b5_r1_b}
C {iopin.sym} 7920 -530 0 0 {name=p1104 lab=b5_r1_b_not}
C {iopin.sym} 7920 -470 0 0 {name=p1105 lab=b5_r2_b}
C {iopin.sym} 7920 -450 0 0 {name=p1106 lab=b5_r2_b_not}
C {iopin.sym} 7920 -390 0 0 {name=p1107 lab=b5_r3_b}
C {iopin.sym} 7920 -370 0 0 {name=p1108 lab=b5_r3_b_not}
C {iopin.sym} 7920 -310 0 0 {name=p1109 lab=b5_r4_b}
C {iopin.sym} 7920 -290 0 0 {name=p1110 lab=b5_r4_b_not}
C {iopin.sym} 7920 -230 0 0 {name=p1111 lab=b5_r5_b}
C {iopin.sym} 7920 -210 0 0 {name=p1112 lab=b5_r5_b_not}
C {iopin.sym} 7920 -150 0 0 {name=p1113 lab=b5_r6_b}
C {iopin.sym} 7920 -130 0 0 {name=p1114 lab=b5_r6_b_not}
C {iopin.sym} 7920 -70 0 0 {name=p1115 lab=b5_r7_b}
C {iopin.sym} 7920 -50 0 0 {name=p1116 lab=b5_r7_b_not}
C {lab_wire.sym} 7920 -430 0 0 {name=p1117 sig_type=std_logic lab=x4_s3}
C {lab_wire.sym} 7920 -410 0 0 {name=p1118 sig_type=std_logic lab=x4_s3_not}
C {lab_wire.sym} 7920 -350 0 0 {name=p1119 sig_type=std_logic lab=x4_s4}
C {lab_wire.sym} 7920 -330 0 0 {name=p1120 sig_type=std_logic lab=x4_s4_not}
C {lab_wire.sym} 7920 -270 0 0 {name=p1121 sig_type=std_logic lab=x4_s5}
C {lab_wire.sym} 7920 -250 0 0 {name=p1122 sig_type=std_logic lab=x4_s5_not}
C {lab_wire.sym} 7920 -190 0 0 {name=p1123 sig_type=std_logic lab=x4_s6}
C {lab_wire.sym} 7920 -170 0 0 {name=p1124 sig_type=std_logic lab=x4_s6_not}
C {lab_wire.sym} 7920 -110 0 0 {name=p1125 sig_type=std_logic lab=x4_s7}
C {lab_wire.sym} 7920 -90 0 0 {name=p1126 sig_type=std_logic lab=x4_s7_not}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 9017.5 -600 0 0 {name=x54}
C {lab_wire.sym} 9017.5 -770 0 0 {name=p1127 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 8857.5 -630 0 0 {name=p1128 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} 8857.5 -650 0 0 {name=p1129 sig_type=std_logic lab=a0}
C {lab_wire.sym} 8857.5 -590 0 0 {name=p1130 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} 8857.5 -610 0 0 {name=p1131 sig_type=std_logic lab=b6}
C {lab_wire.sym} 9007.5 -440 0 0 {name=p1132 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 9017.5 -235 0 0 {name=x55}
C {lab_wire.sym} 9017.5 -405 0 0 {name=p1133 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 8857.5 -265 0 0 {name=p1134 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} 8857.5 -285 0 0 {name=p1135 sig_type=std_logic lab=a1}
C {lab_wire.sym} 8857.5 -225 0 0 {name=p1136 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} 8857.5 -245 0 0 {name=p1137 sig_type=std_logic lab=b6}
C {lab_wire.sym} 9007.5 -75 0 0 {name=p1138 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 9017.5 130 0 0 {name=x56}
C {lab_wire.sym} 9017.5 -40 0 0 {name=p1139 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 8857.5 100 0 0 {name=p1142 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} 8857.5 80 0 0 {name=p1143 sig_type=std_logic lab=a2}
C {lab_wire.sym} 8857.5 140 0 0 {name=p1144 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} 8857.5 120 0 0 {name=p1145 sig_type=std_logic lab=b6}
C {lab_wire.sym} 9007.5 290 0 0 {name=p1146 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 9017.5 495 0 0 {name=x57}
C {lab_wire.sym} 9017.5 325 0 0 {name=p1147 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 8857.5 465 0 0 {name=p1148 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} 8857.5 445 0 0 {name=p1149 sig_type=std_logic lab=a3}
C {lab_wire.sym} 8857.5 505 0 0 {name=p1150 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} 8857.5 485 0 0 {name=p1151 sig_type=std_logic lab=b6}
C {lab_wire.sym} 9007.5 655 0 0 {name=p1152 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 9017.5 872.5 0 0 {name=x58}
C {lab_wire.sym} 9017.5 702.5 0 0 {name=p1153 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 8857.5 842.5 0 0 {name=p1154 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} 8857.5 822.5 0 0 {name=p1155 sig_type=std_logic lab=a4}
C {lab_wire.sym} 8857.5 882.5 0 0 {name=p1156 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} 8857.5 862.5 0 0 {name=p1157 sig_type=std_logic lab=b6}
C {lab_wire.sym} 9007.5 1032.5 0 0 {name=p1158 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 9017.5 1237.5 0 0 {name=x59}
C {lab_wire.sym} 9017.5 1067.5 0 0 {name=p1159 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 8857.5 1207.5 0 0 {name=p1160 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} 8857.5 1187.5 0 0 {name=p1161 sig_type=std_logic lab=a5}
C {lab_wire.sym} 8857.5 1247.5 0 0 {name=p1162 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} 8857.5 1227.5 0 0 {name=p1163 sig_type=std_logic lab=b6}
C {lab_wire.sym} 9007.5 1397.5 0 0 {name=p1164 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 9017.5 1602.5 0 0 {name=x60}
C {lab_wire.sym} 9017.5 1432.5 0 0 {name=p1165 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 8857.5 1572.5 0 0 {name=p1166 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} 8857.5 1552.5 0 0 {name=p1167 sig_type=std_logic lab=a6}
C {lab_wire.sym} 8857.5 1612.5 0 0 {name=p1168 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} 8857.5 1592.5 0 0 {name=p1169 sig_type=std_logic lab=b6}
C {lab_wire.sym} 9007.5 1762.5 0 0 {name=p1170 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 9017.5 1967.5 0 0 {name=x61}
C {lab_wire.sym} 9017.5 1797.5 0 0 {name=p1171 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 8857.5 1937.5 0 0 {name=p1172 sig_type=std_logic lab=a7_not}
C {lab_wire.sym} 8857.5 1917.5 0 0 {name=p1173 sig_type=std_logic lab=a7}
C {lab_wire.sym} 8857.5 1977.5 0 0 {name=p1174 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} 8857.5 1957.5 0 0 {name=p1175 sig_type=std_logic lab=b6}
C {lab_wire.sym} 9007.5 2127.5 0 0 {name=p1176 sig_type=std_logic lab=vss}
C {lab_wire.sym} 9177.5 -570 0 0 {name=p1177 sig_type=std_logic lab=b6_r0}
C {lab_wire.sym} 9177.5 -550 0 0 {name=p1178 sig_type=std_logic lab=b6_r0_not}
C {lab_wire.sym} 9177.5 -205 0 0 {name=p1179 sig_type=std_logic lab=b6_r1}
C {lab_wire.sym} 9177.5 -185 0 0 {name=p1180 sig_type=std_logic lab=b6_r1_not}
C {lab_wire.sym} 9177.5 160 0 0 {name=p1181 sig_type=std_logic lab=b6_r2}
C {lab_wire.sym} 9177.5 180 0 0 {name=p1182 sig_type=std_logic lab=b6_r2_not}
C {lab_wire.sym} 9177.5 525 0 0 {name=p1183 sig_type=std_logic lab=b6_r3}
C {lab_wire.sym} 9177.5 545 0 0 {name=p1184 sig_type=std_logic lab=b6_r3_not}
C {lab_wire.sym} 9177.5 902.5 0 0 {name=p1185 sig_type=std_logic lab=b6_r4}
C {lab_wire.sym} 9177.5 922.5 0 0 {name=p1186 sig_type=std_logic lab=b6_r4_not}
C {lab_wire.sym} 9177.5 1267.5 0 0 {name=p1187 sig_type=std_logic lab=b6_r5}
C {lab_wire.sym} 9177.5 1287.5 0 0 {name=p1188 sig_type=std_logic lab=b6_r5_not}
C {lab_wire.sym} 9177.5 1632.5 0 0 {name=p1189 sig_type=std_logic lab=b6_r6}
C {lab_wire.sym} 9177.5 1652.5 0 0 {name=p1190 sig_type=std_logic lab=b6_r6_not}
C {lab_wire.sym} 9177.5 1997.5 0 0 {name=p1191 sig_type=std_logic lab=b6_r7}
C {lab_wire.sym} 9177.5 2017.5 0 0 {name=p1192 sig_type=std_logic lab=b6_r7_not}
C {iopin.sym} 8857.5 -570 2 0 {name=p1193 lab=b6_c0}
C {iopin.sym} 8857.5 -550 2 0 {name=p1194 lab=b6_c0_not}
C {iopin.sym} 9177.5 -610 0 0 {name=p1195 lab=b6_q0}
C {iopin.sym} 9177.5 -590 0 0 {name=p1196 lab=b6_q0_not}
C {iopin.sym} 9177.5 -650 0 0 {name=p1197 lab=b6_p0}
C {iopin.sym} 9177.5 -630 0 0 {name=p1198 lab=b6_p0_not}
C {iopin.sym} 9177.5 -245 0 0 {name=p1199 lab=b6_q1}
C {iopin.sym} 9177.5 -225 0 0 {name=p1200 lab=b6_q1_not}
C {iopin.sym} 9177.5 -285 0 0 {name=p1201 lab=b6_p1}
C {iopin.sym} 9177.5 -265 0 0 {name=p1202 lab=b6_p1_not}
C {iopin.sym} 8857.5 -205 2 0 {name=p1203 lab=b6_c1}
C {iopin.sym} 8857.5 -185 2 0 {name=p1204 lab=b6_c1_not}
C {iopin.sym} 9177.5 120 0 0 {name=p1205 lab=b6_q2}
C {iopin.sym} 9177.5 140 0 0 {name=p1206 lab=b6_q2_not}
C {iopin.sym} 9177.5 80 0 0 {name=p1207 lab=b6_p2}
C {iopin.sym} 9177.5 100 0 0 {name=p1208 lab=b6_p2_not}
C {iopin.sym} 9177.5 485 0 0 {name=p1209 lab=b6_q3}
C {iopin.sym} 9177.5 505 0 0 {name=p1210 lab=b6_q3_not}
C {iopin.sym} 9177.5 445 0 0 {name=p1211 lab=b6_p3}
C {iopin.sym} 9177.5 465 0 0 {name=p1212 lab=b6_p3_not}
C {iopin.sym} 9177.5 862.5 0 0 {name=p1213 lab=b6_q4}
C {iopin.sym} 9177.5 882.5 0 0 {name=p1214 lab=b6_q4_not}
C {iopin.sym} 9177.5 822.5 0 0 {name=p1215 lab=b6_p4}
C {iopin.sym} 9177.5 842.5 0 0 {name=p1216 lab=b6_p4_not}
C {iopin.sym} 9177.5 1227.5 0 0 {name=p1217 lab=b6_q5}
C {iopin.sym} 9177.5 1247.5 0 0 {name=p1218 lab=b6_q5_not}
C {iopin.sym} 9177.5 1187.5 0 0 {name=p1219 lab=b6_p5}
C {iopin.sym} 9177.5 1207.5 0 0 {name=p1220 lab=b6_p5_not}
C {iopin.sym} 9177.5 1592.5 0 0 {name=p1221 lab=b6_q6}
C {iopin.sym} 9177.5 1612.5 0 0 {name=p1222 lab=b6_q6_not}
C {iopin.sym} 9177.5 1552.5 0 0 {name=p1223 lab=b6_p6}
C {iopin.sym} 9177.5 1572.5 0 0 {name=p1224 lab=b6_p6_not}
C {iopin.sym} 9177.5 1957.5 0 0 {name=p1225 lab=b6_q7}
C {iopin.sym} 9177.5 1977.5 0 0 {name=p1226 lab=b6_q7_not}
C {iopin.sym} 9177.5 1917.5 0 0 {name=p1227 lab=b6_p7}
C {iopin.sym} 9177.5 1937.5 0 0 {name=p1228 lab=b6_p7_not}
C {iopin.sym} 8857.5 525 2 0 {name=p1229 lab=b6_c3}
C {iopin.sym} 8857.5 545 2 0 {name=p1230 lab=b6_c3_not}
C {iopin.sym} 8857.5 902.5 2 0 {name=p1231 lab=b6_c4}
C {iopin.sym} 8857.5 922.5 2 0 {name=p1232 lab=b6_c4_not}
C {iopin.sym} 8857.5 1267.5 2 0 {name=p1233 lab=b6_c5}
C {iopin.sym} 8857.5 1287.5 2 0 {name=p1234 lab=b6_c5_not}
C {iopin.sym} 8857.5 1632.5 2 0 {name=p1235 lab=b6_c6}
C {iopin.sym} 8857.5 1652.5 2 0 {name=p1236 lab=b6_c6_not}
C {iopin.sym} 8857.5 1997.5 2 0 {name=p1237 lab=b6_c7}
C {iopin.sym} 8857.5 2017.5 2 0 {name=p1238 lab=b6_c7_not}
C {lab_wire.sym} 9862.5 -740 0 0 {name=p1239 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 9862.5 70 0 0 {name=p1240 sig_type=std_logic lab=vss}
C {lab_wire.sym} 9702.5 -630 0 0 {name=p1241 sig_type=std_logic lab=b6_r0}
C {lab_wire.sym} 9702.5 -610 0 0 {name=p1242 sig_type=std_logic lab=b6_r0_not}
C {lab_wire.sym} 9702.5 -670 0 0 {name=p1243 sig_type=std_logic lab=x4_s1}
C {lab_wire.sym} 9702.5 -650 0 0 {name=p1244 sig_type=std_logic lab=x4_s1_not}
C {iopin.sym} 9692.5 -710 2 0 {name=p1245 lab=x5_c0_f}
C {iopin.sym} 9692.5 -690 2 0 {name=p1246 lab=x5_c0_f_not}
C {lab_wire.sym} 9702.5 -550 0 0 {name=p1247 sig_type=std_logic lab=b6_r1}
C {lab_wire.sym} 9702.5 -530 0 0 {name=p1248 sig_type=std_logic lab=b6_r1_not}
C {lab_wire.sym} 9702.5 -590 0 0 {name=p1249 sig_type=std_logic lab=x4_s2}
C {lab_wire.sym} 9702.5 -570 0 0 {name=p1250 sig_type=std_logic lab=x4_s2_not}
C {lab_wire.sym} 9702.5 -470 0 0 {name=p1251 sig_type=std_logic lab=b6_r2}
C {lab_wire.sym} 9702.5 -450 0 0 {name=p1252 sig_type=std_logic lab=b6_r2_not}
C {lab_wire.sym} 9702.5 -510 0 0 {name=p1253 sig_type=std_logic lab=x4_s3}
C {lab_wire.sym} 9702.5 -490 0 0 {name=p1254 sig_type=std_logic lab=x4_s3_not}
C {lab_wire.sym} 9702.5 -390 0 0 {name=p1255 sig_type=std_logic lab=b6_r3}
C {lab_wire.sym} 9702.5 -370 0 0 {name=p1256 sig_type=std_logic lab=b6_r3_not}
C {lab_wire.sym} 9702.5 -430 0 0 {name=p1257 sig_type=std_logic lab=x4_s4}
C {lab_wire.sym} 9702.5 -410 0 0 {name=p1258 sig_type=std_logic lab=x4_s4_not}
C {lab_wire.sym} 9702.5 -310 0 0 {name=p1259 sig_type=std_logic lab=b6_r4}
C {lab_wire.sym} 9702.5 -290 0 0 {name=p1260 sig_type=std_logic lab=b6_r4_not}
C {lab_wire.sym} 9702.5 -350 0 0 {name=p1261 sig_type=std_logic lab=x4_s5}
C {lab_wire.sym} 9702.5 -330 0 0 {name=p1262 sig_type=std_logic lab=x4_s5_not}
C {lab_wire.sym} 9702.5 -230 0 0 {name=p1263 sig_type=std_logic lab=b6_r5}
C {lab_wire.sym} 9702.5 -210 0 0 {name=p1264 sig_type=std_logic lab=b6_r5_not}
C {lab_wire.sym} 9702.5 -270 0 0 {name=p1265 sig_type=std_logic lab=x4_s6}
C {lab_wire.sym} 9702.5 -250 0 0 {name=p1266 sig_type=std_logic lab=x4_s6_not}
C {lab_wire.sym} 9702.5 -150 0 0 {name=p1267 sig_type=std_logic lab=b6_r6}
C {lab_wire.sym} 9702.5 -130 0 0 {name=p1268 sig_type=std_logic lab=b6_r6_not}
C {lab_wire.sym} 9702.5 -190 0 0 {name=p1269 sig_type=std_logic lab=x4_s7}
C {lab_wire.sym} 9702.5 -170 0 0 {name=p1270 sig_type=std_logic lab=x4_s7_not}
C {lab_wire.sym} 9702.5 -70 0 0 {name=p1271 sig_type=std_logic lab=b6_r7}
C {lab_wire.sym} 9702.5 -50 0 0 {name=p1272 sig_type=std_logic lab=b6_r7_not}
C {lab_wire.sym} 9702.5 -110 0 0 {name=p1273 sig_type=std_logic lab=x4_s8}
C {lab_wire.sym} 9702.5 -90 0 0 {name=p1274 sig_type=std_logic lab=x4_s8_not}
C {final_project/devices/8b_FA_ripple/8b_FA_ripple.sym} 9862.5 -80 0 0 {name=x62}
C {symbols/nfet_03v3.sym} 10155 70 0 0 {name=M41
L=0.55u
W=1.37u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 10445 70 2 0 {name=M42
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {iopin.sym} 10085 250 2 0 {name=p1275 lab=x5_b0_f}
C {lab_wire.sym} 10225 70 2 0 {name=p1276 sig_type=std_logic lab=vss}
C {lab_wire.sym} 10375 70 0 0 {name=p1277 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 10155 190 0 0 {name=M43
L=0.55u
W=1.415u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 10445 190 2 0 {name=M44
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 10225 190 2 0 {name=p1278 sig_type=std_logic lab=vss}
C {lab_wire.sym} 10375 190 0 0 {name=p1279 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 10155 310 0 0 {name=M45
L=0.55u
W=1.365u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 10445 310 2 0 {name=M46
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 10225 310 2 0 {name=p1280 sig_type=std_logic lab=vss}
C {lab_wire.sym} 10375 310 0 0 {name=p1281 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 10155 430 0 0 {name=M47
L=0.55u
W=1.385u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 10445 430 2 0 {name=M48
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 10225 430 2 0 {name=p1282 sig_type=std_logic lab=vss}
C {lab_wire.sym} 10375 430 0 0 {name=p1283 sig_type=std_logic lab=vdd}
C {iopin.sym} 10085 490 2 0 {name=p1284 lab=x5_b0_f_not
}
C {lab_wire.sym} 10525 110 0 0 {name=p1285 sig_type=std_logic lab=x5_s8}
C {lab_wire.sym} 10525 350 0 0 {name=p1286 sig_type=std_logic lab=x5_s8_not}
C {iopin.sym} 10022.5 -670 0 0 {name=p1287 lab=p6}
C {iopin.sym} 10022.5 -650 0 0 {name=p1288 lab=p6_not}
C {iopin.sym} 10022.5 -710 0 0 {name=p1289 lab=x5_c0_b}
C {iopin.sym} 10022.5 -690 0 0 {name=p1290 lab=x5_c0_b_not}
C {iopin.sym} 10022.5 -630 0 0 {name=p1291 lab=b6_r0_b}
C {iopin.sym} 10022.5 -610 0 0 {name=p1292 lab=b6_r0_b_not}
C {lab_wire.sym} 10022.5 -590 0 0 {name=p1293 sig_type=std_logic lab=x5_s1}
C {lab_wire.sym} 10022.5 -570 0 0 {name=p1294 sig_type=std_logic lab=x5_s1_not}
C {lab_wire.sym} 10022.5 -510 0 0 {name=p1295 sig_type=std_logic lab=x5_s2}
C {lab_wire.sym} 10022.5 -490 0 0 {name=p1296 sig_type=std_logic lab=x5_s2_not}
C {iopin.sym} 10022.5 -550 0 0 {name=p1297 lab=b6_r1_b}
C {iopin.sym} 10022.5 -530 0 0 {name=p1298 lab=b6_r1_b_not}
C {iopin.sym} 10022.5 -470 0 0 {name=p1299 lab=b6_r2_b}
C {iopin.sym} 10022.5 -450 0 0 {name=p1300 lab=b6_r2_b_not}
C {iopin.sym} 10022.5 -390 0 0 {name=p1301 lab=b6_r3_b}
C {iopin.sym} 10022.5 -370 0 0 {name=p1302 lab=b6_r3_b_not}
C {iopin.sym} 10022.5 -310 0 0 {name=p1303 lab=b6_r4_b}
C {iopin.sym} 10022.5 -290 0 0 {name=p1304 lab=b6_r4_b_not}
C {iopin.sym} 10022.5 -230 0 0 {name=p1305 lab=b6_r5_b}
C {iopin.sym} 10022.5 -210 0 0 {name=p1306 lab=b6_r5_b_not}
C {iopin.sym} 10022.5 -150 0 0 {name=p1307 lab=b6_r6_b}
C {iopin.sym} 10022.5 -130 0 0 {name=p1308 lab=b6_r6_b_not}
C {iopin.sym} 10022.5 -70 0 0 {name=p1309 lab=b6_r7_b}
C {iopin.sym} 10022.5 -50 0 0 {name=p1310 lab=b6_r7_b_not}
C {lab_wire.sym} 10022.5 -430 0 0 {name=p1311 sig_type=std_logic lab=x5_s3}
C {lab_wire.sym} 10022.5 -410 0 0 {name=p1312 sig_type=std_logic lab=x5_s3_not}
C {lab_wire.sym} 10022.5 -350 0 0 {name=p1313 sig_type=std_logic lab=x5_s4}
C {lab_wire.sym} 10022.5 -330 0 0 {name=p1314 sig_type=std_logic lab=x5_s4_not}
C {lab_wire.sym} 10022.5 -270 0 0 {name=p1315 sig_type=std_logic lab=x5_s5}
C {lab_wire.sym} 10022.5 -250 0 0 {name=p1316 sig_type=std_logic lab=x5_s5_not}
C {lab_wire.sym} 10022.5 -190 0 0 {name=p1317 sig_type=std_logic lab=x5_s6}
C {lab_wire.sym} 10022.5 -170 0 0 {name=p1318 sig_type=std_logic lab=x5_s6_not}
C {lab_wire.sym} 10022.5 -110 0 0 {name=p1319 sig_type=std_logic lab=x5_s7}
C {lab_wire.sym} 10022.5 -90 0 0 {name=p1320 sig_type=std_logic lab=x5_s7_not}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 11195 -565 0 0 {name=x63}
C {lab_wire.sym} 11195 -735 0 0 {name=p1321 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 11035 -595 0 0 {name=p1322 sig_type=std_logic lab=a0_not}
C {lab_wire.sym} 11035 -615 0 0 {name=p1323 sig_type=std_logic lab=a0}
C {lab_wire.sym} 11035 -555 0 0 {name=p1324 sig_type=std_logic lab=b7_not}
C {lab_wire.sym} 11035 -575 0 0 {name=p1325 sig_type=std_logic lab=b7}
C {lab_wire.sym} 11185 -405 0 0 {name=p1326 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 11195 -200 0 0 {name=x64}
C {lab_wire.sym} 11195 -370 0 0 {name=p1327 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 11035 -230 0 0 {name=p1328 sig_type=std_logic lab=a1_not}
C {lab_wire.sym} 11035 -250 0 0 {name=p1329 sig_type=std_logic lab=a1}
C {lab_wire.sym} 11035 -190 0 0 {name=p1330 sig_type=std_logic lab=b7_not}
C {lab_wire.sym} 11035 -210 0 0 {name=p1331 sig_type=std_logic lab=b7}
C {lab_wire.sym} 11185 -40 0 0 {name=p1332 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 11195 165 0 0 {name=x65}
C {lab_wire.sym} 11195 -5 0 0 {name=p1333 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 11035 135 0 0 {name=p1336 sig_type=std_logic lab=a2_not}
C {lab_wire.sym} 11035 115 0 0 {name=p1337 sig_type=std_logic lab=a2}
C {lab_wire.sym} 11035 175 0 0 {name=p1338 sig_type=std_logic lab=b7_not}
C {lab_wire.sym} 11035 155 0 0 {name=p1339 sig_type=std_logic lab=b7}
C {lab_wire.sym} 11185 325 0 0 {name=p1340 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 11195 530 0 0 {name=x66}
C {lab_wire.sym} 11195 360 0 0 {name=p1341 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 11035 500 0 0 {name=p1342 sig_type=std_logic lab=a3_not}
C {lab_wire.sym} 11035 480 0 0 {name=p1343 sig_type=std_logic lab=a3}
C {lab_wire.sym} 11035 540 0 0 {name=p1344 sig_type=std_logic lab=b7_not}
C {lab_wire.sym} 11035 520 0 0 {name=p1345 sig_type=std_logic lab=b7}
C {lab_wire.sym} 11185 690 0 0 {name=p1346 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 11195 907.5 0 0 {name=x67}
C {lab_wire.sym} 11195 737.5 0 0 {name=p1347 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 11035 877.5 0 0 {name=p1348 sig_type=std_logic lab=a4_not}
C {lab_wire.sym} 11035 857.5 0 0 {name=p1349 sig_type=std_logic lab=a4}
C {lab_wire.sym} 11035 917.5 0 0 {name=p1350 sig_type=std_logic lab=b7_not}
C {lab_wire.sym} 11035 897.5 0 0 {name=p1351 sig_type=std_logic lab=b7}
C {lab_wire.sym} 11185 1067.5 0 0 {name=p1352 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 11195 1272.5 0 0 {name=x68}
C {lab_wire.sym} 11195 1102.5 0 0 {name=p1353 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 11035 1242.5 0 0 {name=p1354 sig_type=std_logic lab=a5_not}
C {lab_wire.sym} 11035 1222.5 0 0 {name=p1355 sig_type=std_logic lab=a5}
C {lab_wire.sym} 11035 1282.5 0 0 {name=p1356 sig_type=std_logic lab=b7_not}
C {lab_wire.sym} 11035 1262.5 0 0 {name=p1357 sig_type=std_logic lab=b7}
C {lab_wire.sym} 11185 1432.5 0 0 {name=p1358 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 11195 1637.5 0 0 {name=x69}
C {lab_wire.sym} 11195 1467.5 0 0 {name=p1359 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 11035 1607.5 0 0 {name=p1360 sig_type=std_logic lab=a6_not}
C {lab_wire.sym} 11035 1587.5 0 0 {name=p1361 sig_type=std_logic lab=a6}
C {lab_wire.sym} 11035 1647.5 0 0 {name=p1362 sig_type=std_logic lab=b7_not}
C {lab_wire.sym} 11035 1627.5 0 0 {name=p1363 sig_type=std_logic lab=b7}
C {lab_wire.sym} 11185 1797.5 0 0 {name=p1364 sig_type=std_logic lab=vss}
C {final_project/standard_cells/CCNOT/CCNOT.sym} 11195 2002.5 0 0 {name=x70}
C {lab_wire.sym} 11195 1832.5 0 0 {name=p1365 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 11035 1972.5 0 0 {name=p1366 sig_type=std_logic lab=a7_not}
C {lab_wire.sym} 11035 1952.5 0 0 {name=p1367 sig_type=std_logic lab=a7}
C {lab_wire.sym} 11035 2012.5 0 0 {name=p1368 sig_type=std_logic lab=b7_not}
C {lab_wire.sym} 11035 1992.5 0 0 {name=p1369 sig_type=std_logic lab=b7}
C {lab_wire.sym} 11185 2162.5 0 0 {name=p1370 sig_type=std_logic lab=vss}
C {lab_wire.sym} 11355 -535 0 0 {name=p1371 sig_type=std_logic lab=b7_r0}
C {lab_wire.sym} 11355 -515 0 0 {name=p1372 sig_type=std_logic lab=b7_r0_not}
C {lab_wire.sym} 11355 -170 0 0 {name=p1373 sig_type=std_logic lab=b7_r1}
C {lab_wire.sym} 11355 -150 0 0 {name=p1374 sig_type=std_logic lab=b7_r1_not}
C {lab_wire.sym} 11355 195 0 0 {name=p1375 sig_type=std_logic lab=b7_r2}
C {lab_wire.sym} 11355 215 0 0 {name=p1376 sig_type=std_logic lab=b7_r2_not}
C {lab_wire.sym} 11355 560 0 0 {name=p1377 sig_type=std_logic lab=b7_r3}
C {lab_wire.sym} 11355 580 0 0 {name=p1378 sig_type=std_logic lab=b7_r3_not}
C {lab_wire.sym} 11355 937.5 0 0 {name=p1379 sig_type=std_logic lab=b7_r4}
C {lab_wire.sym} 11355 957.5 0 0 {name=p1380 sig_type=std_logic lab=b7_r4_not}
C {lab_wire.sym} 11355 1302.5 0 0 {name=p1381 sig_type=std_logic lab=b7_r5}
C {lab_wire.sym} 11355 1322.5 0 0 {name=p1382 sig_type=std_logic lab=b7_r5_not}
C {lab_wire.sym} 11355 1667.5 0 0 {name=p1383 sig_type=std_logic lab=b7_r6}
C {lab_wire.sym} 11355 1687.5 0 0 {name=p1384 sig_type=std_logic lab=b7_r6_not}
C {lab_wire.sym} 11355 2032.5 0 0 {name=p1385 sig_type=std_logic lab=b7_r7}
C {lab_wire.sym} 11355 2052.5 0 0 {name=p1386 sig_type=std_logic lab=b7_r7_not}
C {iopin.sym} 11035 -535 2 0 {name=p1387 lab=b7_c0}
C {iopin.sym} 11035 -515 2 0 {name=p1388 lab=b7_c0_not}
C {iopin.sym} 11355 -575 0 0 {name=p1389 lab=b7_q0}
C {iopin.sym} 11355 -555 0 0 {name=p1390 lab=b7_q0_not}
C {iopin.sym} 11355 -615 0 0 {name=p1391 lab=b7_p0}
C {iopin.sym} 11355 -595 0 0 {name=p1392 lab=b7_p0_not}
C {iopin.sym} 11355 -210 0 0 {name=p1393 lab=b7_q1}
C {iopin.sym} 11355 -190 0 0 {name=p1394 lab=b7_q1_not}
C {iopin.sym} 11355 -250 0 0 {name=p1395 lab=b7_p1}
C {iopin.sym} 11355 -230 0 0 {name=p1396 lab=b7_p1_not}
C {iopin.sym} 11035 -170 2 0 {name=p1397 lab=b7_c1}
C {iopin.sym} 11035 -150 2 0 {name=p1398 lab=b7_c1_not}
C {iopin.sym} 11355 155 0 0 {name=p1399 lab=b7_q2}
C {iopin.sym} 11355 175 0 0 {name=p1400 lab=b7_q2_not}
C {iopin.sym} 11355 115 0 0 {name=p1401 lab=b7_p2}
C {iopin.sym} 11355 135 0 0 {name=p1402 lab=b7_p2_not}
C {iopin.sym} 11355 520 0 0 {name=p1403 lab=b7_q3}
C {iopin.sym} 11355 540 0 0 {name=p1404 lab=b7_q3_not}
C {iopin.sym} 11355 480 0 0 {name=p1405 lab=b7_p3}
C {iopin.sym} 11355 500 0 0 {name=p1406 lab=b7_p3_not}
C {iopin.sym} 11355 897.5 0 0 {name=p1407 lab=b7_q4}
C {iopin.sym} 11355 917.5 0 0 {name=p1408 lab=b7_q4_not}
C {iopin.sym} 11355 857.5 0 0 {name=p1409 lab=b7_p4}
C {iopin.sym} 11355 877.5 0 0 {name=p1410 lab=b7_p4_not}
C {iopin.sym} 11355 1262.5 0 0 {name=p1411 lab=b7_q5}
C {iopin.sym} 11355 1282.5 0 0 {name=p1412 lab=b7_q5_not}
C {iopin.sym} 11355 1222.5 0 0 {name=p1413 lab=b7_p5}
C {iopin.sym} 11355 1242.5 0 0 {name=p1414 lab=b7_p5_not}
C {iopin.sym} 11355 1627.5 0 0 {name=p1415 lab=b7_q6}
C {iopin.sym} 11355 1647.5 0 0 {name=p1416 lab=b7_q6_not}
C {iopin.sym} 11355 1587.5 0 0 {name=p1417 lab=b7_p6}
C {iopin.sym} 11355 1607.5 0 0 {name=p1418 lab=b7_p6_not}
C {iopin.sym} 11355 1992.5 0 0 {name=p1419 lab=b7_q7}
C {iopin.sym} 11355 2012.5 0 0 {name=p1420 lab=b7_q7_not}
C {iopin.sym} 11355 1952.5 0 0 {name=p1421 lab=b7_p7}
C {iopin.sym} 11355 1972.5 0 0 {name=p1422 lab=b7_p7_not}
C {iopin.sym} 11035 560 2 0 {name=p1423 lab=b7_c3}
C {iopin.sym} 11035 580 2 0 {name=p1424 lab=b7_c3_not}
C {iopin.sym} 11035 937.5 2 0 {name=p1425 lab=b7_c4}
C {iopin.sym} 11035 957.5 2 0 {name=p1426 lab=b7_c4_not}
C {iopin.sym} 11035 1302.5 2 0 {name=p1427 lab=b7_c5}
C {iopin.sym} 11035 1322.5 2 0 {name=p1428 lab=b7_c5_not}
C {iopin.sym} 11035 1667.5 2 0 {name=p1429 lab=b7_c6}
C {iopin.sym} 11035 1687.5 2 0 {name=p1430 lab=b7_c6_not}
C {iopin.sym} 11035 2032.5 2 0 {name=p1431 lab=b7_c7}
C {iopin.sym} 11035 2052.5 2 0 {name=p1432 lab=b7_c7_not}
C {lab_wire.sym} 12180 -712.5 0 0 {name=p1433 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 12180 97.5 0 0 {name=p1434 sig_type=std_logic lab=vss}
C {lab_wire.sym} 12020 -602.5 0 0 {name=p1435 sig_type=std_logic lab=b7_r0}
C {lab_wire.sym} 12020 -582.5 0 0 {name=p1436 sig_type=std_logic lab=b7_r0_not}
C {lab_wire.sym} 12020 -642.5 0 0 {name=p1437 sig_type=std_logic lab=x5_s1}
C {lab_wire.sym} 12020 -622.5 0 0 {name=p1438 sig_type=std_logic lab=x5_s1_not}
C {iopin.sym} 12010 -682.5 2 0 {name=p1439 lab=x6_c0_f}
C {iopin.sym} 12010 -662.5 2 0 {name=p1440 lab=x6_c0_f_not}
C {lab_wire.sym} 12020 -522.5 0 0 {name=p1441 sig_type=std_logic lab=b7_r1}
C {lab_wire.sym} 12020 -502.5 0 0 {name=p1442 sig_type=std_logic lab=b7_r1_not}
C {lab_wire.sym} 12020 -562.5 0 0 {name=p1443 sig_type=std_logic lab=x5_s2}
C {lab_wire.sym} 12020 -542.5 0 0 {name=p1444 sig_type=std_logic lab=x5_s2_not}
C {lab_wire.sym} 12020 -442.5 0 0 {name=p1445 sig_type=std_logic lab=b7_r2}
C {lab_wire.sym} 12020 -422.5 0 0 {name=p1446 sig_type=std_logic lab=b7_r2_not}
C {lab_wire.sym} 12020 -482.5 0 0 {name=p1447 sig_type=std_logic lab=x5_s3}
C {lab_wire.sym} 12020 -462.5 0 0 {name=p1448 sig_type=std_logic lab=x5_s3_not}
C {lab_wire.sym} 12020 -362.5 0 0 {name=p1449 sig_type=std_logic lab=b7_r3}
C {lab_wire.sym} 12020 -342.5 0 0 {name=p1450 sig_type=std_logic lab=b7_r3_not}
C {lab_wire.sym} 12020 -402.5 0 0 {name=p1451 sig_type=std_logic lab=x5_s4}
C {lab_wire.sym} 12020 -382.5 0 0 {name=p1452 sig_type=std_logic lab=x5_s4_not}
C {lab_wire.sym} 12020 -282.5 0 0 {name=p1453 sig_type=std_logic lab=b7_r4}
C {lab_wire.sym} 12020 -262.5 0 0 {name=p1454 sig_type=std_logic lab=b7_r4_not}
C {lab_wire.sym} 12020 -322.5 0 0 {name=p1455 sig_type=std_logic lab=x5_s5}
C {lab_wire.sym} 12020 -302.5 0 0 {name=p1456 sig_type=std_logic lab=x5_s5_not}
C {lab_wire.sym} 12020 -202.5 0 0 {name=p1457 sig_type=std_logic lab=b7_r5}
C {lab_wire.sym} 12020 -182.5 0 0 {name=p1458 sig_type=std_logic lab=b7_r5_not}
C {lab_wire.sym} 12020 -242.5 0 0 {name=p1459 sig_type=std_logic lab=x5_s6}
C {lab_wire.sym} 12020 -222.5 0 0 {name=p1460 sig_type=std_logic lab=x5_s6_not}
C {lab_wire.sym} 12020 -122.5 0 0 {name=p1461 sig_type=std_logic lab=b7_r6}
C {lab_wire.sym} 12020 -102.5 0 0 {name=p1462 sig_type=std_logic lab=b7_r6_not}
C {lab_wire.sym} 12020 -162.5 0 0 {name=p1463 sig_type=std_logic lab=x5_s7}
C {lab_wire.sym} 12020 -142.5 0 0 {name=p1464 sig_type=std_logic lab=x5_s7_not}
C {lab_wire.sym} 12020 -42.5 0 0 {name=p1465 sig_type=std_logic lab=b7_r7}
C {lab_wire.sym} 12020 -22.5 0 0 {name=p1466 sig_type=std_logic lab=b7_r7_not}
C {lab_wire.sym} 12020 -82.5 0 0 {name=p1467 sig_type=std_logic lab=x5_s8}
C {lab_wire.sym} 12020 -62.5 0 0 {name=p1468 sig_type=std_logic lab=x5_s8_not}
C {final_project/devices/8b_FA_ripple/8b_FA_ripple.sym} 12180 -52.5 0 0 {name=x71}
C {symbols/nfet_03v3.sym} 12472.5 97.5 0 0 {name=M49
L=0.55u
W=1.37u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 12762.5 97.5 2 0 {name=M50
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {iopin.sym} 12402.5 277.5 2 0 {name=p1469 lab=x6_b0_f}
C {lab_wire.sym} 12542.5 97.5 2 0 {name=p1470 sig_type=std_logic lab=vss}
C {lab_wire.sym} 12692.5 97.5 0 0 {name=p1471 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 12472.5 217.5 0 0 {name=M51
L=0.55u
W=1.415u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 12762.5 217.5 2 0 {name=M52
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 12542.5 217.5 2 0 {name=p1472 sig_type=std_logic lab=vss}
C {lab_wire.sym} 12692.5 217.5 0 0 {name=p1473 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 12472.5 337.5 0 0 {name=M53
L=0.55u
W=1.365u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 12762.5 337.5 2 0 {name=M54
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 12542.5 337.5 2 0 {name=p1474 sig_type=std_logic lab=vss}
C {lab_wire.sym} 12692.5 337.5 0 0 {name=p1475 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 12472.5 457.5 0 0 {name=M55
L=0.55u
W=1.385u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 12762.5 457.5 2 0 {name=M56
L=0.5u
W=1.235u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 12542.5 457.5 2 0 {name=p1476 sig_type=std_logic lab=vss}
C {lab_wire.sym} 12692.5 457.5 0 0 {name=p1477 sig_type=std_logic lab=vdd}
C {iopin.sym} 12402.5 517.5 2 0 {name=p1478 lab=x6_b0_f_not
}
C {iopin.sym} 12340 -642.5 0 0 {name=p1481 lab=p7}
C {iopin.sym} 12340 -622.5 0 0 {name=p1482 lab=p7_not}
C {iopin.sym} 12340 -682.5 0 0 {name=p1483 lab=x6_c0_b}
C {iopin.sym} 12340 -662.5 0 0 {name=p1484 lab=x6_c0_b_not}
C {iopin.sym} 12340 -602.5 0 0 {name=p1485 lab=b7_r0_b}
C {iopin.sym} 12340 -582.5 0 0 {name=p1486 lab=b7_r0_b_not}
C {iopin.sym} 12340 -522.5 0 0 {name=p1491 lab=b7_r1_b}
C {iopin.sym} 12340 -502.5 0 0 {name=p1492 lab=b7_r1_b_not}
C {iopin.sym} 12340 -442.5 0 0 {name=p1493 lab=b7_r2_b}
C {iopin.sym} 12340 -422.5 0 0 {name=p1494 lab=b7_r2_b_not}
C {iopin.sym} 12340 -362.5 0 0 {name=p1495 lab=b7_r3_b}
C {iopin.sym} 12340 -342.5 0 0 {name=p1496 lab=b7_r3_b_not}
C {iopin.sym} 12340 -282.5 0 0 {name=p1497 lab=b7_r4_b}
C {iopin.sym} 12340 -262.5 0 0 {name=p1498 lab=b7_r4_b_not}
C {iopin.sym} 12340 -202.5 0 0 {name=p1499 lab=b7_r5_b}
C {iopin.sym} 12340 -182.5 0 0 {name=p1500 lab=b7_r5_b_not}
C {iopin.sym} 12340 -122.5 0 0 {name=p1501 lab=b7_r6_b}
C {iopin.sym} 12340 -102.5 0 0 {name=p1502 lab=b7_r6_b_not}
C {iopin.sym} 12340 -42.5 0 0 {name=p1503 lab=b7_r7_b}
C {iopin.sym} 12340 -22.5 0 0 {name=p1504 lab=b7_r7_b_not}
C {iopin.sym} 12340 -562.5 0 0 {name=p1487 lab=p8}
C {iopin.sym} 12340 -542.5 0 0 {name=p1488 lab=p8_not}
C {iopin.sym} 12340 -482.5 0 0 {name=p1489 lab=p9}
C {iopin.sym} 12340 -462.5 0 0 {name=p1490 lab=p9_not}
C {iopin.sym} 12340 -402.5 0 0 {name=p1505 lab=p10}
C {iopin.sym} 12340 -382.5 0 0 {name=p1506 lab=p10_not}
C {iopin.sym} 12340 -322.5 0 0 {name=p1507 lab=p11}
C {iopin.sym} 12340 -302.5 0 0 {name=p1508 lab=p11_not}
C {iopin.sym} 12340 -242.5 0 0 {name=p1509 lab=p12}
C {iopin.sym} 12340 -222.5 0 0 {name=p1510 lab=p12_not}
C {iopin.sym} 12340 -162.5 0 0 {name=p1511 lab=p13}
C {iopin.sym} 12340 -142.5 0 0 {name=p1512 lab=p13_not}
C {iopin.sym} 12340 -82.5 0 0 {name=p1513 lab=p14}
C {iopin.sym} 12340 -62.5 0 0 {name=p1514 lab=p14_not}
C {iopin.sym} 12842.5 137.5 0 0 {name=p1479 lab=p15}
C {iopin.sym} 12842.5 377.5 0 0 {name=p1480 lab=p15_not}
C {iopin.sym} 8857.5 160 2 0 {name=p1515 lab=b6_c2}
C {iopin.sym} 8857.5 180 2 0 {name=p1516 lab=b6_c2_not}
C {iopin.sym} 11035 195 2 0 {name=p1140 lab=b7_c2}
C {iopin.sym} 11035 215 2 0 {name=p1141 lab=b7_c2_not}
C {iopin.sym} 4842.5 172.5 2 0 {name=p752 lab=b4_c2}
C {iopin.sym} 4842.5 192.5 2 0 {name=p753 lab=b4_c2_not}
C {iopin.sym} 2980 197.5 2 0 {name=p558 lab=b3_c2}
C {iopin.sym} 2980 217.5 2 0 {name=p559 lab=b3_c2_not}
C {iopin.sym} 1207.5 197.5 2 0 {name=p260 lab=b2_c2}
C {iopin.sym} 1207.5 217.5 2 0 {name=p261 lab=b2_c2_not}
C {iopin.sym} 6742.5 182.5 2 0 {name=p946 lab=b5_c2}
C {iopin.sym} 6742.5 202.5 2 0 {name=p947 lab=b5_c2_not}
C {iopin.sym} -1760 -605 2 0 {name=p1334 lab=b2_not}
C {iopin.sym} -1760 -625 2 0 {name=p1335 lab=b2}
C {iopin.sym} -1760 -565 2 0 {name=p1517 lab=b3_not}
C {iopin.sym} -1760 -585 2 0 {name=p1518 lab=b3}
C {lab_wire.sym} -1690 -625 0 0 {name=p1519 sig_type=std_logic lab=b2}
C {lab_wire.sym} -1690 -605 0 0 {name=p1520 sig_type=std_logic lab=b2_not}
C {lab_wire.sym} -1690 -585 0 0 {name=p1521 sig_type=std_logic lab=b3}
C {lab_wire.sym} -1690 -565 0 0 {name=p1522 sig_type=std_logic lab=b3_not}
C {iopin.sym} -1760 -525 2 0 {name=p1523 lab=b4_not}
C {iopin.sym} -1760 -545 2 0 {name=p1524 lab=b4}
C {iopin.sym} -1760 -485 2 0 {name=p1525 lab=b5_not}
C {iopin.sym} -1760 -505 2 0 {name=p1526 lab=b5}
C {lab_wire.sym} -1690 -545 0 0 {name=p1527 sig_type=std_logic lab=b4}
C {lab_wire.sym} -1690 -525 0 0 {name=p1528 sig_type=std_logic lab=b4_not}
C {lab_wire.sym} -1690 -505 0 0 {name=p1529 sig_type=std_logic lab=b5}
C {lab_wire.sym} -1690 -485 0 0 {name=p1530 sig_type=std_logic lab=b5_not}
C {iopin.sym} -1760 -445 2 0 {name=p1531 lab=b6_not}
C {iopin.sym} -1760 -465 2 0 {name=p1532 lab=b6}
C {iopin.sym} -1760 -405 2 0 {name=p1533 lab=b7_not}
C {iopin.sym} -1760 -425 2 0 {name=p1534 lab=b7}
C {lab_wire.sym} -1690 -465 0 0 {name=p1535 sig_type=std_logic lab=b6}
C {lab_wire.sym} -1690 -445 0 0 {name=p1536 sig_type=std_logic lab=b6_not}
C {lab_wire.sym} -1690 -425 0 0 {name=p1537 sig_type=std_logic lab=b7}
C {lab_wire.sym} -1690 -405 0 0 {name=p1538 sig_type=std_logic lab=b7_not}
